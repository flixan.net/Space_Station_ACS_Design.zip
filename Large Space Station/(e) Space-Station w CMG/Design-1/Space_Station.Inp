MODE# 29/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4561       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Right RCS Thruster Assembl    1050     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Left RCS Thrusters Assembl    2050    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Top Left RCS Thrusters Assembl    2050    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Bottom Right RCS Thruster Asse    1150     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Right RCS Thruster Asse    1150     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Left RCS Thrusters Asse    2150    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03
Bottom Left RCS Thrusters Asse    2150    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.31485D-02   0.20823D-01   0.48539D-02   0.48023D-04  -0.11767D-03   0.39456D-03

MODE# 30/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.8273       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Right RCS Thruster Assembl    1050    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Left RCS Thrusters Assembl    2050     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Top Left RCS Thrusters Assembl    2050     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Bottom Right RCS Thruster Asse    1150    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Right RCS Thruster Asse    1150    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Left RCS Thrusters Asse    2150     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02
Bottom Left RCS Thrusters Asse    2150     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.26998D-03   0.10382D-02  -0.24181D-02   0.15716D-03   0.20293D-04  -0.14251D-04

MODE# 31/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.5067       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Right RCS Thruster Assembl    1050    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Left RCS Thrusters Assembl    2050     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Top Left RCS Thrusters Assembl    2050     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Bottom Right RCS Thruster Asse    1150    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Right RCS Thruster Asse    1150    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Left RCS Thrusters Asse    2150     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03
Bottom Left RCS Thrusters Asse    2150     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.52544D-02  -0.28136D-01  -0.19374D-01   0.69462D-03   0.27740D-03  -0.96521D-03

MODE# 32/ 51, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.4150       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.34577D-02  -0.25538D-02   0.17986D-01   0.13026D-03  -0.52134D-04   0.11134D-03
Top Right RCS Thruster Assembl    1050    -0.34577D-02  -0.25538D-02   0.17986D-01   0.13026D-03  -0.52134D-04   0.11134D-03
Top Left RCS Thrusters Assembl    2050     0.11287D-01  -0.16182D-02  -0.99253D-02   0.89821D-04  -0.27574D-03   0.16790D-03
Top Left RCS Thrusters Assembl    2050     0.11287D-01  -0.16182D-02  -0.99253D-02   0.89821D-04  -0.27574D-03   0.16790D-03
Bottom Right RCS Thruster Asse    1150    -0.12183D-02  -0.34289D-02   0.18359D-01   0.20858D-03   0.31081D-04   0.33678D-04
Bottom Right RCS Thruster Asse    1150    -0.12183D-02  -0.34289D-02   0.18359D-01   0.20858D-03   0.31081D-04   0.33678D-04
Bottom Left RCS Thrusters Asse    2150     0.34645D-02  -0.43587D-02  -0.10176D-01   0.16219D-03   0.14839D-03   0.83215D-04
Bottom Left RCS Thrusters Asse    2150     0.34645D-02  -0.43587D-02  -0.10176D-01   0.16219D-03   0.14839D-03   0.83215D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.36308D-02   0.30770D-02   0.17629D-01  -0.21670D-03   0.26746D-04  -0.44555D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.13092D-01  -0.76273D-03   0.78456D-02   0.67138D-03   0.10868D-02   0.60264D-03
Center Habitat Module             9007    -0.13092D-01  -0.76273D-03   0.78456D-02   0.67138D-03   0.10868D-02   0.60264D-03
Center Habitat Module             9007    -0.13092D-01  -0.76273D-03   0.78456D-02   0.67138D-03   0.10868D-02   0.60264D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.62030D-02   0.27544D-02   0.77558D-02
Right Solar Array Boom            6070     0.62030D-02   0.27544D-02   0.77558D-02
Left SA Boom, Extreme end         5070    -0.12188D-01   0.60682D-02  -0.13195D-03
Left SA Boom, Extreme end         5070    -0.12188D-01   0.60682D-02  -0.13195D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.74549D-02  -0.20683D-01  -0.51404D-02   0.83666D-03   0.36612D-04   0.19586D-03

MODE# 33/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.6158       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Right RCS Thruster Assembl    1050     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Left RCS Thrusters Assembl    2050    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Top Left RCS Thrusters Assembl    2050    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Bottom Right RCS Thruster Asse    1150     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Right RCS Thruster Asse    1150     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Left RCS Thrusters Asse    2150     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05
Bottom Left RCS Thrusters Asse    2150     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.24741D-02   0.14001D-01  -0.53449D-02  -0.38579D-03   0.11357D-03   0.36721D-03

MODE# 34/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.2010       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Right RCS Thruster Assembl    1050     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Left RCS Thrusters Assembl    2050    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Top Left RCS Thrusters Assembl    2050    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Bottom Right RCS Thruster Asse    1150     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Right RCS Thruster Asse    1150     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Left RCS Thrusters Asse    2150    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03
Bottom Left RCS Thrusters Asse    2150    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.13367D-01   0.10809D-02   0.26664D-01  -0.20114D-03   0.46546D-04  -0.12775D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.46806D-02  -0.43565D-03   0.46398D-02
Right Solar Array Boom            6070    -0.46806D-02  -0.43565D-03   0.46398D-02
Left SA Boom, Extreme end         5070     0.13990D-01   0.47949D-02  -0.65422D-02
Left SA Boom, Extreme end         5070     0.13990D-01   0.47949D-02  -0.65422D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.96058D-02   0.92243D-02  -0.11756D-01   0.85290D-03   0.15622D-05   0.61819D-03
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Station with Double-Gimbal CMG Array (Rigid)
System
vehicle_rigid
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Station with Double-Gimbal CMG Array (Flex)
System
vehicle_flex34
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Station with Double-Gimbal CMG Array (Design Plant)
System
design_plant
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Station with Double-Gimbal CMG Array (LVLH Plant)
System
lvlh_plant
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Augmented Design Plant
System
augm_plant
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
LQR State-Feedback Gain for Augmented Design Plant
Matrix Kpqr
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
