BATCH MODE INSTRUCTIONS ...............
Batch for Large Flexible Space Station                                                                 
! This batch set creates a models for a Space Station that is 
! controlled by an array of double-gimbal CMGs. Two models
! are created, a rigid-body model and a flexible model using the 
! attached modal data. The design model is extracted from Rigid Vehicle
! and the plant state is transformed so that it is equal to the Output, C=I
!
Retain Matrix    : State Weight Matrix Qc (12x12)                                                                        
Retain Matrix    : Control Weight Matrix Rc (3x3)                                                                       
!
Flight Vehicle   : Space Station with Double-Gimbal CMG Array (Rigid)                                                                                            
Flight Vehicle   : Space Station with Double-Gimbal CMG Array (Flex) 
System Modificat : Space Station with Double-Gimbal CMG Array (Design Plant)      
System Modificat : Space Station with Double-Gimbal CMG Array (LVLH Plant)                                                                                      
Transf-Function  : 3 Integrators
System Connection: Augmented Design Plant  
LQR Control Des  : LQR Control Design for Augmented Space Station Model   
!
To Matlab Format : Space Station with Double-Gimbal CMG Array (Rigid)                                                                                           
To Matlab Format : Space Station with Double-Gimbal CMG Array (Flex)                                                                                            
To Matlab Format : Space Station with Double-Gimbal CMG Array (Design Plant)  
To Matlab Format : Space Station with Double-Gimbal CMG Array (LVLH Plant) 
To Matlab Format : Augmented Design Plant 
To Matlab Format : LQR State-Feedback Gain for Augmented Design Plant 
------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Space Station with Double-Gimbal CMG Array (Rigid)
!
! The Space Station state-space model is created using the vehicle modeling program.
! The model uses an array of double-gimbal control moment gyros, 3 rate 
! gyros, 3 attitude sensors, and 4 accelerometers. The Station is initialized at the 
! Local Vertical Local Horizontal (LVLH) attitude and it has a negative pitch rate 
! -0.063 radians/sec which is equal to the orbital rate. The vehicle rates are with 
! respect to the LVLH frame. A constant bias torque 7.40153 (ft-lb) is applied
! in the direction (-0.1969, 0.5963, 0.7781) to represent the steady-state gyroscopic 
! and gravity-gradient torques due to the constant pitch rate
Body Axes Output, LVLH Attitude & Rate
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   6200.0       32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.119416e+9  0.40408e+8   0.110166e+9, 0.476e+7,    0.1216e+7,   0.30121e+6    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   0.0          0.0          0.0 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.0          25500.0      0.0001       700000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.0          0.0          0.0          0.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0          0.0          0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       0.000        0.0000       0.0000      -0.063        0.0000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Torque       0.196972    -0.596376    -0.778163 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   0.0          1.0          1.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   0.0          0.0          0.0         -0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    

Number of External Torques on the Vehicle                                                :  3
Torque No  1  Direction (x, y, z)                                                        :  1.0           0.0         0.0
Torque No  2  Direction (x, y, z)                                                        :  0.0           1.0         0.0
Torque No  3  Direction (x, y, z)                                                        :  0.0           0.0         1.0

Double Gimbal Control Moment Gyro System  (3-axes), Initial Momentum (x,y,z) (ft-lb-sec) :  Yes           0.0    0.0   0.0

Number of Gyros, (Attitude and Rate)                                                     :  6
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Rate            0.0        82.0      0.0
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Rate            0.0        82.0      0.0
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Rate            0.0        82.0      0.0
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Attitude        0.0        82.0      0.0
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Attitude        0.0        82.0      0.0
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Attitude        0.0        82.0      0.0

Number of Accelerometers, Along Axes: (x,y,z)                                            :  4
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  X-axis Accelerat.      0.0      232.35    18.0
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  Z-axis Accelerat.      0.0      232.35    18.0
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  X-axis Accelerat.      0.0     -224.63    16.0
Acceleromet No  4 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  Z-axis Accelerat.      0.0     -224.63    16.0

Number of Bending Modes                                                                  :  0
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Space Station with Double-Gimbal CMG Array (Flex)
!
! The Space Station state-space model is now created using the vehicle modeling program.
! The model uses an array of double-gimbal control moment gyros, 3 rate gyros,
! 3 attitude sensors, and 4 accelerometers. The Station is initialized at the 
! Local Vertical Local Horizontal (LVLH) attitude and it has a negative pitch rate 
! -0.063 radians/sec which is equal to the orbital rate. The vehicle rates are with 
! respect to the LVLH frame. A constant bias torque 7.40153 (ft-lb) is applied
! in the direction (-0.1969, 0.5963, 0.7781) to represent the steady-state gyroscopic 
! and gravity-gradient torques due to the constant pitch rate
Body Axes Output, LVLH Attitude & Rate
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   6200.0       32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.119416e+9  0.40408e+8   0.110166e+9, 0.476e+7,   0.1216e+7,   0.30121e+6    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   0.0          0.0          0.0 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.0          25500.0      0.0001       700000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.0          0.0          0.0          0.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0          0.0          0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       0.000        0.0000       0.0000      -0.063        0.0000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Torque       0.196972    -0.596376    -0.778163 
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   0.0          1.0          1.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   0.0          0.0          0.0         -0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    

Number of External Torques on the Vehicle                                                :  3
Torque No  1  Direction (x, y, z)                                                        :  1.0           0.0         0.0
Torque No  2  Direction (x, y, z)                                                        :  0.0           1.0         0.0
Torque No  3  Direction (x, y, z)                                                        :  0.0           0.0         1.0

Double Gimbal Control Moment Gyro System  (3-axes), Initial Momentum (x,y,z) (ft-lb-sec) :  Yes           0.0    0.0   0.0

Number of Gyros, (Attitude and Rate)                                                     :  6
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Rate            0.0        82.0      0.0
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Rate            0.0        82.0      0.0
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Rate            0.0        82.0      0.0
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Attitude        0.0        82.0      0.0
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Attitude        0.0        82.0      0.0
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Attitude        0.0        82.0      0.0

Number of Accelerometers, Along Axes: (x,y,z)                                            :  4
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  X-axis Accelerat.      0.0      232.35    18.0
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  Z-axis Accelerat.      0.0      232.35    18.0
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  X-axis Accelerat.      0.0     -224.63    16.0
Acceleromet No  4 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  Z-axis Accelerat.      0.0     -224.63    16.0

Number of Bending Modes                                                                  : 34
Space Station with Double-Gimbal CMG Array, 34 Flex Modes            
---------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Space Station with Double-Gimbal CMG Array (Design Plant)                                       
Space Station with Double-Gimbal CMG Array (Rigid)                
! Create the Station Design Model by Reducing the Rigid-Body Model     
! Inputs are the CMG Control Torques
! Outputs are: LVLH attitude and rates, and CMG Momentum
!                           
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   2   3
Extract States :   1   3   5   2   4   6  11  12  13
Extract Outputs:   1   3   5   2   4   6  16  17  18
-------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Space Station with Double-Gimbal CMG Array (LVLH Plant)                                       
Space Station with Double-Gimbal CMG Array (Design Plant)              
! Transform the design plant and make the States equal to the Outputs
SYSTEM TRANSFORMATION, STATES EQUAL TO OUTPUTS
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
3 Integrators
! Used to calculate the CMG Momentum Integral for the LQR Optimization
Continuous
TF. Block #  1  Integrator x                                     Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
TF. Block #  2  Integrator y                                     Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
TF. Block #  3  Integrator z                                     Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
......................................................
Block #, from Input #, Gain
      1             1       1.0
      2             2       1.0
      3             3       1.0
...........................
Outpt #, from Block #, Gain
      1             1       1.0
      2             2       1.0
      3             3       1.0
...........................
Definitions of Inputs  =   3
CMG Momentum-X 
CMG Momentum-Y
CMG Momentum-Z
 
Definitions of Outputs =   3
CMG Momentum-X Integral
CMG Momentum-Y Integral
CMG Momentum-Z Integral
------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Augmented Design Plant
! Augment the Design Plant by including the Momentum Integral and the 
! Oscillation Filters
Titles of Systems to be Combined          (Found in File Comb_tst.Qdr)
Title 1 Space Station with Double-Gimbal CMG Array (LVLH Plant)  
Title 2 3 Integrators
SYSTEM INPUTS TO SUBSYSTEM  1
Via Matrix +I3                                                                                 3 CMG Control Torques
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                               9 Original Plant States
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                                       3 LVLH Attitudes
System Output  2 from Subsystem  1, Output  2, Gain= 1.0
System Output  3 from Subsystem  1, Output  3, Gain= 1.0
System Output  4 from Subsystem  1, Output  4, Gain= 1.0                                       3 LVLH Rates
System Output  5 from Subsystem  1, Output  5, Gain= 1.0
System Output  6 from Subsystem  1, Output  6, Gain= 1.0
System Output  7 from Subsystem  1, Output  7, Gain= 1.0                                       3 CMG Momentum
System Output  8 from Subsystem  1, Output  8, Gain= 1.0
System Output  9 from Subsystem  1, Output  9, Gain= 1.0
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                               3 Momentum Integrals
System Output 10 from Subsystem  2, Output  1, Gain= 1.0                                       H-integr-X
System Output 11 from Subsystem  2, Output  2, Gain= 1.0                                       H-integr-Y
System Output 12 from Subsystem  2, Output  3, Gain= 1.0                                       H-integr-Z
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                        to Momentum Integrator
Subsystem  1, Output  7 to Subsystem  2, Input  1, Gain=  1.0                                  CMG Momentm-X
Subsystem  1, Output  8 to Subsystem  2, Input  2, Gain=  1.0                                  CMG Momentm-Y
Subsystem  1, Output  9 to Subsystem  2, Input  3, Gain=  1.0                                  CMG Momentm-Z
......................................................................
Definitions of Inputs  =   3
Roll CMG Momentum (ft-lb)
Ptch CMG Momentum (ft-lb)
Yaw  CMG Momentum (ft-lb)

Definitions of Outputs =  12
Roll Attitude  (phi-LVLH)  (radians)                                            
Pitch Attitude (thet-LVLH) (radians)                                            
Yaw  Attitude  (psi-LVLH)  (radians)                                            
Roll Rate      (p-lvlh)    (rad/sec)                                            
Pitch Rate     (q-lvlh)    (rad/sec)                                            
Yaw  Rate      (r-lvlh)    (rad/sec)                                            
CMG Momentum in X-axis (ft-lb-sec)                         
CMG Momentum in Y-axis (ft-lb-sec)                         
CMG Momentum in Z-axis (ft-lb-sec)  
CMG Momentum Integral X (ft-lb-sec^2)                         
CMG Momentum Integral Y (ft-lb-sec^2)   
CMG Momentum Integral Z (ft-lb-sec^2)   
-------------------------------------------------------------------------------
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
LQR Control Design for Augmented Space Station Model                                                                                                                                      
Plant Model Used to Design the Control System from:        Augmented Design Plant                                                                                                             
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc12                State Weight Matrix Qc (12x12)                                                                                                                
Control Penalty Weight (Rc) is Matrix: Rc3                 Control Weight Matrix Rc (3x3)                                                                                                                                                            
Continuous LQR Solution Using Assymptotic Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kpqr                LQR State-Feedback Gain for Augmented Design Plant                                                
------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : 34 Modes  
Space Station with Double-Gimbal CMG Array, 34 Flex Modes            
! 34 modes were selected from all directions. The same modes as in Previous Examples. 
! The first 6 Rigid-Body Modes were not included

MODE#  1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.0097       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.11384D-02  -0.58736D-04   0.96470D-04  -0.23552D-06  -0.30827D-04   0.65746D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07
Center Habitat Module             9007     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07
Center Habitat Module             9007     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.25921D-01  -0.73995D-04  -0.57584D-04
Right Solar Array Boom            6070    -0.25921D-01  -0.73995D-04  -0.57584D-04
Left SA Boom, Extreme end         5070    -0.26691D-01   0.68332D-05  -0.15103D-03
Left SA Boom, Extreme end         5070    -0.26691D-01   0.68332D-05  -0.15103D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.28820D-02  -0.73445D-04   0.35876D-03   0.49346D-06  -0.54146D-05  -0.28216D-06

MODE#  2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.0255       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.16243D-02   0.18219D-02   0.16059D-03   0.37075D-05  -0.69558D-06  -0.16075D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04
Center Habitat Module             9007     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04
Center Habitat Module             9007     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.47651D-02   0.18134D-02   0.16250D-02
Right Solar Array Boom            6070     0.47651D-02   0.18134D-02   0.16250D-02
Left SA Boom, Extreme end         5070    -0.42523D-02   0.18158D-02  -0.18308D-02
Left SA Boom, Extreme end         5070    -0.42523D-02   0.18158D-02  -0.18308D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.30520D-03   0.69682D-03   0.13621D-03  -0.13573D-05  -0.19247D-05  -0.29404D-04

MODE#  3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.1385       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.40181D-02  -0.20058D-04   0.20510D-03  -0.19664D-05  -0.11022D-03   0.19217D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06
Center Habitat Module             9007     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06
Center Habitat Module             9007     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.84761D-01  -0.23417D-04  -0.17658D-02
Right Solar Array Boom            6070    -0.84761D-01  -0.23417D-04  -0.17658D-02
Left SA Boom, Extreme end         5070    -0.87937D-01  -0.32226D-04  -0.25058D-02
Left SA Boom, Extreme end         5070    -0.87937D-01  -0.32226D-04  -0.25058D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.95692D-02  -0.19903D-03   0.46251D-03   0.21385D-05  -0.26851D-05  -0.13445D-05

MODE#  4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2538       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.70262D-04   0.78376D-04   0.15821D-03   0.61854D-05  -0.18467D-04  -0.30878D-05

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05
Center Habitat Module             9007    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05
Center Habitat Module             9007    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.11135D-02   0.77862D-04   0.40662D-02
Right Solar Array Boom            6070     0.11135D-02   0.77862D-04   0.40662D-02
Left SA Boom, Extreme end         5070     0.11659D-02   0.70474D-04   0.32605D-02
Left SA Boom, Extreme end         5070     0.11659D-02   0.70474D-04   0.32605D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.22082D-03   0.23081D-04   0.22118D-03   0.39973D-05  -0.98563D-05   0.12769D-05

MODE#  5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2560       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.13200D-02  -0.17334D-03  -0.77745D-04  -0.27079D-04   0.12276D-04  -0.12158D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05
Center Habitat Module             9007    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05
Center Habitat Module             9007    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.37620D-02  -0.16761D-03  -0.24578D-01
Right Solar Array Boom            6070     0.37620D-02  -0.16761D-03  -0.24578D-01
Left SA Boom, Extreme end         5070     0.35787D-02  -0.11463D-03  -0.25536D-01
Left SA Boom, Extreme end         5070     0.35787D-02  -0.11463D-03  -0.25536D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.32285D-03  -0.23092D-03  -0.19637D-02  -0.13880D-05   0.70075D-04  -0.19967D-05

MODE#  6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2724       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.27086D-02  -0.53892D-03  -0.72511D-04   0.34288D-05   0.17716D-05  -0.35293D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04
Center Habitat Module             9007     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04
Center Habitat Module             9007     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10629D-01  -0.54165D-03   0.30329D-02
Right Solar Array Boom            6070     0.10629D-01  -0.54165D-03   0.30329D-02
Left SA Boom, Extreme end         5070    -0.10597D-01  -0.54799D-03   0.26902D-02
Left SA Boom, Extreme end         5070    -0.10597D-01  -0.54799D-03   0.26902D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.37323D-03  -0.22865D-02  -0.51211D-04  -0.79422D-06  -0.29755D-05  -0.43171D-04

MODE#  7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2905       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.27553D-03   0.16845D-03  -0.90551D-03   0.26039D-04   0.62764D-04  -0.79699D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05
Center Habitat Module             9007    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05
Center Habitat Module             9007    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.40195D-01   0.16692D-03   0.22993D-01
Right Solar Array Boom            6070     0.40195D-01   0.16692D-03   0.22993D-01
Left SA Boom, Extreme end         5070     0.42191D-01   0.10951D-03   0.23745D-01
Left SA Boom, Extreme end         5070     0.42191D-01   0.10951D-03   0.23745D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.25831D-02   0.26793D-03  -0.17573D-02  -0.16295D-06  -0.36426D-05   0.18950D-05

MODE#  8/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2972       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.81986D-04  -0.63207D-03   0.35878D-02  -0.10523D-03  -0.80440D-04  -0.34210D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05
Center Habitat Module             9007    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05
Center Habitat Module             9007    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.16152D-01  -0.60789D-03  -0.92556D-01
Right Solar Array Boom            6070     0.16152D-01  -0.60789D-03  -0.92556D-01
Left SA Boom, Extreme end         5070     0.13509D-01  -0.40151D-03  -0.94027D-01
Left SA Boom, Extreme end         5070     0.13509D-01  -0.40151D-03  -0.94027D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.10092D-02  -0.70457D-03   0.71454D-02  -0.33947D-05   0.95791D-05  -0.47374D-05

MODE#  9/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.9041       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.55088D-02  -0.14705D-02  -0.16691D-01   0.29272D-05  -0.28298D-03  -0.40991D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04
Center Habitat Module             9007     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04
Center Habitat Module             9007     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.92888D-02  -0.15132D-02   0.30178D-01
Right Solar Array Boom            6070     0.92888D-02  -0.15132D-02   0.30178D-01
Left SA Boom, Extreme end         5070     0.15541D-01  -0.15722D-02   0.15987D-01
Left SA Boom, Extreme end         5070     0.15541D-01  -0.15722D-02   0.15987D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.68334D-03  -0.30893D-02  -0.34341D-01  -0.64458D-04   0.50412D-03  -0.67055D-04

MODE# 10/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    2.0858       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.24017D-01  -0.11178D-01  -0.93641D-02  -0.11276D-03   0.67165D-04  -0.14243D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03
Center Habitat Module             9007     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03
Center Habitat Module             9007     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.58119D-01  -0.11392D-01   0.29485D-01
Right Solar Array Boom            6070    -0.58119D-01  -0.11392D-01   0.29485D-01
Left SA Boom, Extreme end         5070     0.52744D-01  -0.11290D-01  -0.33691D-01
Left SA Boom, Extreme end         5070     0.52744D-01  -0.11290D-01  -0.33691D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.52022D-02  -0.26741D-01   0.64394D-02  -0.23191D-03  -0.53257D-04  -0.54769D-03

MODE# 11/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    2.1921       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.11933D-01  -0.22978D-02  -0.24480D-01  -0.27578D-03  -0.18136D-04   0.90617D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03
Center Habitat Module             9007    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03
Center Habitat Module             9007    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.26037D-01  -0.24062D-02   0.63273D-01
Right Solar Array Boom            6070     0.26037D-01  -0.24062D-02   0.63273D-01
Left SA Boom, Extreme end         5070    -0.28041D-01  -0.21711D-02  -0.65793D-01
Left SA Boom, Extreme end         5070    -0.28041D-01  -0.21711D-02  -0.65793D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.25693D-02   0.16821D-01   0.64776D-02  -0.42408D-03  -0.40741D-04   0.29098D-03

MODE# 12/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.0756       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.32345D-02   0.65956D-03   0.71006D-03   0.32050D-04  -0.47929D-03  -0.11410D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05
Center Habitat Module             9007    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05
Center Habitat Module             9007    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.27361D-01   0.67385D-03   0.13286D-01
Right Solar Array Boom            6070     0.27361D-01   0.67385D-03   0.13286D-01
Left SA Boom, Extreme end         5070     0.28521D-01   0.68685D-03  -0.11599D-01
Left SA Boom, Extreme end         5070     0.28521D-01   0.68685D-03  -0.11599D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.16703D-02  -0.10699D-02  -0.12817D-02   0.69954D-04  -0.64286D-05   0.66596D-05

MODE# 13/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.4152       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.73885D-02   0.32383D-02  -0.13324D-02   0.23858D-04   0.39733D-04  -0.19098D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03
Center Habitat Module             9007    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03
Center Habitat Module             9007    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.14533D-01   0.33289D-02   0.11680D-01
Right Solar Array Boom            6070     0.14533D-01   0.33289D-02   0.11680D-01
Left SA Boom, Extreme end         5070    -0.22738D-01   0.34691D-02   0.15481D-01
Left SA Boom, Extreme end         5070    -0.22738D-01   0.34691D-02   0.15481D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.20138D-02   0.52070D-02   0.52933D-02  -0.66245D-04  -0.13102D-03   0.11198D-03

MODE# 14/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.4305       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.29848D-03  -0.35494D-02  -0.21238D-02   0.92490D-04   0.18383D-04   0.41086D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03
Center Habitat Module             9007    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03
Center Habitat Module             9007    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.13564D-01  -0.36593D-02  -0.10645D-01
Right Solar Array Boom            6070    -0.13564D-01  -0.36593D-02  -0.10645D-01
Left SA Boom, Extreme end         5070     0.55886D-02  -0.36294D-02   0.11115D-03
Left SA Boom, Extreme end         5070     0.55886D-02  -0.36294D-02   0.11115D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.35398D-02  -0.12702D-02   0.52898D-02  -0.21172D-03  -0.14578D-03  -0.41600D-04

MODE# 15/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.5128       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.20095D-02   0.28153D-03   0.55770D-02   0.77710D-04  -0.52410D-04   0.91932D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04
Center Habitat Module             9007     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04
Center Habitat Module             9007     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10901D-01   0.34770D-03  -0.38313D-02
Right Solar Array Boom            6070     0.10901D-01   0.34770D-03  -0.38313D-02
Left SA Boom, Extreme end         5070     0.11667D-01   0.60814D-04   0.21169D-02
Left SA Boom, Extreme end         5070     0.11667D-01   0.60814D-04   0.21169D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.80156D-02   0.30977D-03  -0.30834D-02  -0.89602D-04   0.17651D-03   0.22645D-04

MODE# 16/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.9226       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.24274D-01  -0.76881D-02  -0.52700D-03   0.99422D-05   0.75584D-05   0.40000D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03
Center Habitat Module             9007     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03
Center Habitat Module             9007     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.43648D-01  -0.79705D-02   0.50741D-02
Right Solar Array Boom            6070     0.43648D-01  -0.79705D-02   0.50741D-02
Left SA Boom, Extreme end         5070    -0.45818D-01  -0.79181D-02   0.72136D-02
Left SA Boom, Extreme end         5070    -0.45818D-01  -0.79181D-02   0.72136D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.42233D-03   0.17769D-02   0.34600D-02  -0.90323D-04  -0.28463D-04  -0.13222D-04

MODE# 17/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.4863       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.14368D-01  -0.38438D-03   0.52613D-02   0.13964D-03  -0.53080D-03   0.20124D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04
Center Habitat Module             9007     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04
Center Habitat Module             9007     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.35863D-02  -0.24037D-03  -0.98177D-02
Right Solar Array Boom            6070     0.35863D-02  -0.24037D-03  -0.98177D-02
Left SA Boom, Extreme end         5070    -0.58629D-02  -0.95077D-03   0.32684D-02
Left SA Boom, Extreme end         5070    -0.58629D-02  -0.95077D-03   0.32684D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.19313D-02  -0.39475D-03  -0.22370D-01  -0.15734D-04   0.53522D-03   0.29696D-04

MODE# 18/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.5992       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.17826D-01   0.13912D-02  -0.70242D-02  -0.18719D-03  -0.46324D-03  -0.86245D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05
Center Habitat Module             9007    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05
Center Habitat Module             9007    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.32736D-01   0.12239D-02   0.16424D-02
Right Solar Array Boom            6070    -0.32736D-01   0.12239D-02   0.16424D-02
Left SA Boom, Extreme end         5070    -0.10665D-01   0.24529D-02   0.10979D-01
Left SA Boom, Extreme end         5070    -0.10665D-01   0.24529D-02   0.10979D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.20330D-02  -0.19804D-02   0.34808D-01   0.16183D-03  -0.82006D-03  -0.16494D-04

MODE# 19/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.8706       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.12830D-01  -0.12610D-02  -0.36183D-02  -0.12977D-03   0.12042D-03   0.20158D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04
Center Habitat Module             9007     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04
Center Habitat Module             9007     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.71227D-02  -0.14500D-02   0.50761D-02
Right Solar Array Boom            6070     0.71227D-02  -0.14500D-02   0.50761D-02
Left SA Boom, Extreme end         5070     0.28862D-01  -0.95600D-03   0.26536D-02
Left SA Boom, Extreme end         5070     0.28862D-01  -0.95600D-03   0.26536D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.30943D-02   0.10332D-02  -0.70041D-02  -0.16435D-03   0.45275D-03   0.26820D-05

MODE# 20/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.0593       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.56265D-02  -0.27607D-02  -0.94191D-02   0.16288D-03   0.24700D-03  -0.62282D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04
Center Habitat Module             9007    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04
Center Habitat Module             9007    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.97172D-02  -0.30777D-02  -0.20018D-02
Right Solar Array Boom            6070    -0.97172D-02  -0.30777D-02  -0.20018D-02
Left SA Boom, Extreme end         5070    -0.13932D-01  -0.28919D-02   0.13844D-02
Left SA Boom, Extreme end         5070    -0.13932D-01  -0.28919D-02   0.13844D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.62297D-03   0.54326D-02   0.13679D-01  -0.40427D-03  -0.26375D-03   0.44312D-04

MODE# 21/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.2068       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.72411D-02   0.39069D-02   0.11128D-01  -0.10709D-03   0.16699D-03   0.25213D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03
Center Habitat Module             9007     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03
Center Habitat Module             9007     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10201D-01   0.43630D-02   0.52541D-03
Right Solar Array Boom            6070     0.10201D-01   0.43630D-02   0.52541D-03
Left SA Boom, Extreme end         5070     0.10040D-01   0.43201D-02   0.50684D-03
Left SA Boom, Extreme end         5070     0.10040D-01   0.43201D-02   0.50684D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.12916D-02  -0.59701D-02  -0.11698D-02   0.59213D-03  -0.12150D-03  -0.66394D-04

MODE# 22/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.5116       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.87343D-02   0.27891D-03  -0.50462D-02  -0.31898D-04  -0.81319D-04   0.61494D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.31374D-01   0.41582D-03   0.36196D-02
Right Solar Array Boom            6070     0.31374D-01   0.41582D-03   0.36196D-02
Left SA Boom, Extreme end         5070     0.27577D-01   0.63939D-03   0.56146D-03
Left SA Boom, Extreme end         5070     0.27577D-01   0.63939D-03   0.56146D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.28518D-02   0.34118D-02   0.34718D-01  -0.70970D-04  -0.81304D-03   0.42532D-04

MODE# 23/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.6856       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.84405D-03  -0.55166D-03  -0.21475D-02  -0.50188D-04   0.55354D-05   0.67504D-05

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.42382D-03   0.41720D-03   0.16541D-02  -0.32662D-04  -0.44732D-04  -0.20026D-04
Center Habitat Module             9007     0.42382D-03   0.41720D-03   0.16541D-02  -0.32662D-04  -0.44732D-04  -0.20026D-04
Center Habitat Module             9007     0.42382D-03   0.41720D-03   0.16541D-02  -0.32662D-04  -0.44732D-04  -0.20026D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.76156D-02  -0.71704D-03  -0.80844D-03
Right Solar Array Boom            6070    -0.76156D-02  -0.71704D-03  -0.80844D-03
Left SA Boom, Extreme end         5070     0.85388D-02  -0.47326D-03  -0.10297D-02
Left SA Boom, Extreme end         5070     0.85388D-02  -0.47326D-03  -0.10297D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.14711D-03  -0.14769D-02   0.11371D-02  -0.21751D-04   0.94405D-05  -0.28514D-04

MODE# 24/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.7113       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.51490D-02   0.94482D-03  -0.42733D-04  -0.23534D-04  -0.18934D-04   0.23184D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.21090D-01   0.11246D-02   0.46533D-02
Right Solar Array Boom            6070     0.21090D-01   0.11246D-02   0.46533D-02
Left SA Boom, Extreme end         5070     0.19900D-01   0.11410D-02  -0.27416D-02
Left SA Boom, Extreme end         5070     0.19900D-01   0.11410D-02  -0.27416D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.12812D-02   0.14499D-02   0.95570D-02   0.32066D-04  -0.22681D-03   0.21264D-04

MODE# 25/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.8636       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.15887D-02   0.61989D-02   0.21124D-01   0.37013D-03  -0.41712D-04  -0.67442D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.11780D-01   0.78112D-02  -0.19425D-01
Right Solar Array Boom            6070    -0.11780D-01   0.78112D-02  -0.19425D-01
Left SA Boom, Extreme end         5070     0.81602D-02   0.56711D-02  -0.18170D-01
Left SA Boom, Extreme end         5070     0.81602D-02   0.56711D-02  -0.18170D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.44448D-03   0.34497D-02  -0.13690D-01   0.26188D-03   0.35467D-04   0.54371D-04

MODE# 26/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.9866       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.24720D-02   0.10916D-01   0.31714D-02  -0.29072D-03   0.46370D-04  -0.26743D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.12274D-01   0.11975D-01   0.71338D-02
Right Solar Array Boom            6070    -0.12274D-01   0.11975D-01   0.71338D-02
Left SA Boom, Extreme end         5070    -0.17381D-02   0.12642D-01   0.13000D-01
Left SA Boom, Extreme end         5070    -0.17381D-02   0.12642D-01   0.13000D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.21567D-02   0.14402D-01  -0.10475D-01   0.46327D-03   0.24713D-03   0.23039D-03

MODE# 27/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.3161       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.20633D-02  -0.53440D-02  -0.12970D-01   0.27254D-04   0.72259D-05  -0.91795D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.45080D-02  -0.63782D-02   0.45290D-02
Right Solar Array Boom            6070    -0.45080D-02  -0.63782D-02   0.45290D-02
Left SA Boom, Extreme end         5070     0.10462D-01  -0.47219D-02  -0.85103D-02
Left SA Boom, Extreme end         5070     0.10462D-01  -0.47219D-02  -0.85103D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.10192D-02   0.61384D-02   0.57554D-02  -0.21443D-03  -0.10427D-03   0.16043D-03

MODE# 28/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4006       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.66667D-02   0.19865D-02   0.24711D-02  -0.14086D-04   0.17128D-04  -0.21772D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.70207D-02   0.17813D-02  -0.98349D-03
Right Solar Array Boom            6070    -0.70207D-02   0.17813D-02  -0.98349D-03
Left SA Boom, Extreme end         5070    -0.90049D-02   0.41789D-02   0.25185D-02
Left SA Boom, Extreme end         5070    -0.90049D-02   0.41789D-02   0.25185D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.10852D-02   0.23183D-02  -0.10809D-01   0.82996D-04   0.22608D-03   0.18218D-04

MODE# 29/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4561       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.31485D-02   0.20823D-01   0.48539D-02   0.48023D-04  -0.11767D-03   0.39456D-03

MODE# 30/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.8273       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.26998D-03   0.10382D-02  -0.24181D-02   0.15716D-03   0.20293D-04  -0.14251D-04

MODE# 31/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.5067       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.52544D-02  -0.28136D-01  -0.19374D-01   0.69462D-03   0.27740D-03  -0.96521D-03

MODE# 32/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.3010       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.26173D-02   0.11105D-03   0.27980D-02  -0.56922D-05  -0.78553D-04  -0.79990D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.25064D-02  -0.37664D-03  -0.76321D-03   0.44506D-04   0.12456D-03   0.10621D-03
Center Habitat Module             9007    -0.25064D-02  -0.37664D-03  -0.76321D-03   0.44506D-04   0.12456D-03   0.10621D-03
Center Habitat Module             9007    -0.25064D-02  -0.37664D-03  -0.76321D-03   0.44506D-04   0.12456D-03   0.10621D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.28062D-01   0.86729D-05  -0.92887D-02
Right Solar Array Boom            6070    -0.28062D-01   0.86729D-05  -0.92887D-02
Left SA Boom, Extreme end         5070    -0.10588D-01  -0.91131D-05   0.38563D-02
Left SA Boom, Extreme end         5070    -0.10588D-01  -0.91131D-05   0.38563D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.55739D-03  -0.10265D-02  -0.93706D-03   0.74284D-04   0.96854D-05   0.73054D-04

MODE# 33/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.6158       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.24741D-02   0.14001D-01  -0.53449D-02  -0.38579D-03   0.11357D-03   0.36721D-03

