MODE# 22/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.5116       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.40177D-03  -0.42331D-01  -0.58481D-02  -0.21296D-03  -0.51175D-04   0.94598D-04
Top Right RCS Thruster Assembl    1050     0.40177D-03  -0.42331D-01  -0.58481D-02  -0.21296D-03  -0.51175D-04   0.94598D-04
Top Left RCS Thrusters Assembl    2050    -0.49628D-02  -0.41859D-01  -0.20127D-02  -0.23692D-03  -0.77488D-05  -0.17003D-03
Top Left RCS Thrusters Assembl    2050    -0.49628D-02  -0.41859D-01  -0.20127D-02  -0.23692D-03  -0.77488D-05  -0.17003D-03
Bottom Right RCS Thruster Asse    1150     0.28412D-02  -0.34238D-01  -0.45031D-02   0.17861D-03   0.17629D-03   0.27900D-03
Bottom Right RCS Thruster Asse    1150     0.28412D-02  -0.34238D-01  -0.45031D-02   0.17861D-03   0.17629D-03   0.27900D-03
Bottom Left RCS Thrusters Asse    2150     0.20851D-01  -0.34584D-01  -0.33787D-02   0.16201D-03   0.28328D-03  -0.28374D-04
Bottom Left RCS Thrusters Asse    2150     0.20851D-01  -0.34584D-01  -0.33787D-02   0.16201D-03   0.28328D-03  -0.28374D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.87343D-02   0.27891D-03  -0.50462D-02  -0.31898D-04  -0.81319D-04   0.61494D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.31374D-01   0.41582D-03   0.36196D-02
Right Solar Array Boom            6070     0.31374D-01   0.41582D-03   0.36196D-02
Left SA Boom, Extreme end         5070     0.27577D-01   0.63939D-03   0.56146D-03
Left SA Boom, Extreme end         5070     0.27577D-01   0.63939D-03   0.56146D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.28518D-02   0.34118D-02   0.34718D-01  -0.70970D-04  -0.81304D-03   0.42532D-04

MODE# 23/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.6856       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.35298D-02   0.60665D-02  -0.20774D-02   0.51526D-04  -0.24408D-04  -0.31054D-04
Top Right RCS Thruster Assembl    1050     0.35298D-02   0.60665D-02  -0.20774D-02   0.51526D-04  -0.24408D-04  -0.31054D-04
Top Left RCS Thrusters Assembl    2050    -0.15446D-02   0.68395D-02  -0.17997D-02   0.13769D-04  -0.35353D-05  -0.35172D-04
Top Left RCS Thrusters Assembl    2050    -0.15446D-02   0.68395D-02  -0.17997D-02   0.13769D-04  -0.35353D-05  -0.35172D-04
Bottom Right RCS Thruster Asse    1150     0.13442D-02   0.52026D-02  -0.22953D-02  -0.12826D-04  -0.15828D-05  -0.29201D-04
Bottom Right RCS Thruster Asse    1150     0.13442D-02   0.52026D-02  -0.22953D-02  -0.12826D-04  -0.15828D-05  -0.29201D-04
Bottom Left RCS Thrusters Asse    2150    -0.27681D-02   0.44771D-02  -0.15895D-02  -0.47796D-04  -0.17485D-04  -0.23759D-04
Bottom Left RCS Thrusters Asse    2150    -0.27681D-02   0.44771D-02  -0.15895D-02  -0.47796D-04  -0.17485D-04  -0.23759D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.84405D-03  -0.55166D-03  -0.21475D-02  -0.50188D-04   0.55354D-05   0.67504D-05

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.42382D-03   0.41720D-03   0.16541D-02  -0.32662D-04  -0.44732D-04  -0.20026D-04
Center Habitat Module             9007     0.42382D-03   0.41720D-03   0.16541D-02  -0.32662D-04  -0.44732D-04  -0.20026D-04
Center Habitat Module             9007     0.42382D-03   0.41720D-03   0.16541D-02  -0.32662D-04  -0.44732D-04  -0.20026D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04
Right Boom (Sensor Assembly)      6001     0.58032D-03  -0.57346D-03  -0.33785D-02  -0.70517D-04   0.29473D-04   0.19594D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.76156D-02  -0.71704D-03  -0.80844D-03
Right Solar Array Boom            6070    -0.76156D-02  -0.71704D-03  -0.80844D-03
Left SA Boom, Extreme end         5070     0.85388D-02  -0.47326D-03  -0.10297D-02
Left SA Boom, Extreme end         5070     0.85388D-02  -0.47326D-03  -0.10297D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.14711D-03  -0.14769D-02   0.11371D-02  -0.21751D-04   0.94405D-05  -0.28514D-04

MODE# 24/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.7113       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.69217D-03  -0.21677D-01  -0.46064D-03  -0.10020D-03  -0.40916D-04   0.73097D-04
Top Right RCS Thruster Assembl    1050    -0.69217D-03  -0.21677D-01  -0.46064D-03  -0.10020D-03  -0.40916D-04   0.73097D-04
Top Left RCS Thrusters Assembl    2050     0.22853D-02  -0.21465D-01  -0.17503D-02  -0.11064D-03  -0.55212D-04  -0.30785D-04
Top Left RCS Thrusters Assembl    2050     0.22853D-02  -0.21465D-01  -0.17503D-02  -0.11064D-03  -0.55212D-04  -0.30785D-04
Bottom Right RCS Thruster Asse    1150     0.42646D-02  -0.85364D-02   0.10306D-03   0.63965D-04   0.10612D-03   0.62742D-04
Bottom Right RCS Thruster Asse    1150     0.42646D-02  -0.85364D-02   0.10306D-03   0.63965D-04   0.10612D-03   0.62742D-04
Bottom Left RCS Thrusters Asse    2150     0.51422D-02  -0.87098D-02  -0.23245D-02   0.55493D-04   0.10770D-03  -0.54696D-04
Bottom Left RCS Thrusters Asse    2150     0.51422D-02  -0.87098D-02  -0.23245D-02   0.55493D-04   0.10770D-03  -0.54696D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.51490D-02   0.94482D-03  -0.42733D-04  -0.23534D-04  -0.18934D-04   0.23184D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.21090D-01   0.11246D-02   0.46533D-02
Right Solar Array Boom            6070     0.21090D-01   0.11246D-02   0.46533D-02
Left SA Boom, Extreme end         5070     0.19900D-01   0.11410D-02  -0.27416D-02
Left SA Boom, Extreme end         5070     0.19900D-01   0.11410D-02  -0.27416D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.12812D-02   0.14499D-02   0.95570D-02   0.32066D-04  -0.22681D-03   0.21264D-04

MODE# 25/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.8636       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.67316D-02  -0.51642D-01   0.20506D-01  -0.40685D-03  -0.97960D-05  -0.15696D-03
Top Right RCS Thruster Assembl    1050     0.67316D-02  -0.51642D-01   0.20506D-01  -0.40685D-03  -0.97960D-05  -0.15696D-03
Top Left RCS Thrusters Assembl    2050    -0.13585D-01  -0.57622D-01   0.12198D-01  -0.11413D-03   0.12355D-03  -0.15253D-03
Top Left RCS Thrusters Assembl    2050    -0.13585D-01  -0.57622D-01   0.12198D-01  -0.11413D-03   0.12355D-03  -0.15253D-03
Bottom Right RCS Thruster Asse    1150     0.14106D-01  -0.28345D-01   0.22147D-01   0.77478D-04   0.11670D-03  -0.18385D-03
Bottom Right RCS Thruster Asse    1150     0.14106D-01  -0.28345D-01   0.22147D-01   0.77478D-04   0.11670D-03  -0.18385D-03
Bottom Left RCS Thrusters Asse    2150    -0.92732D-02  -0.22786D-01   0.10622D-01   0.34499D-03  -0.41981D-04  -0.16955D-03
Bottom Left RCS Thrusters Asse    2150    -0.92732D-02  -0.22786D-01   0.10622D-01   0.34499D-03  -0.41981D-04  -0.16955D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.15887D-02   0.61989D-02   0.21124D-01   0.37013D-03  -0.41712D-04  -0.67442D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.11780D-01   0.78112D-02  -0.19425D-01
Right Solar Array Boom            6070    -0.11780D-01   0.78112D-02  -0.19425D-01
Left SA Boom, Extreme end         5070     0.81602D-02   0.56711D-02  -0.18170D-01
Left SA Boom, Extreme end         5070     0.81602D-02   0.56711D-02  -0.18170D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.44448D-03   0.34497D-02  -0.13690D-01   0.26188D-03   0.35467D-04   0.54371D-04

MODE# 26/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.9866       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.84824D-02  -0.10133D+00   0.10125D-02  -0.39854D-03  -0.12155D-03  -0.91410D-04
Top Right RCS Thruster Assembl    1050     0.84824D-02  -0.10133D+00   0.10125D-02  -0.39854D-03  -0.12155D-03  -0.91410D-04
Top Left RCS Thrusters Assembl    2050     0.17181D-02  -0.98201D-01  -0.16214D-01  -0.54990D-03  -0.37841D-04  -0.51754D-04
Top Left RCS Thrusters Assembl    2050     0.17181D-02  -0.98201D-01  -0.16214D-01  -0.54990D-03  -0.37841D-04  -0.51754D-04
Bottom Right RCS Thruster Asse    1150     0.83208D-02  -0.37563D-01   0.38653D-02   0.43039D-03   0.56903D-04  -0.23350D-03
Bottom Right RCS Thruster Asse    1150     0.83208D-02  -0.37563D-01   0.38653D-02   0.43039D-03   0.56903D-04  -0.23350D-03
Bottom Left RCS Thrusters Asse    2150    -0.15025D-01  -0.40611D-01  -0.19120D-01   0.28162D-03  -0.14576D-03  -0.15038D-03
Bottom Left RCS Thrusters Asse    2150    -0.15025D-01  -0.40611D-01  -0.19120D-01   0.28162D-03  -0.14576D-03  -0.15038D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.24720D-02   0.10916D-01   0.31714D-02  -0.29072D-03   0.46370D-04  -0.26743D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.12274D-01   0.11975D-01   0.71338D-02
Right Solar Array Boom            6070    -0.12274D-01   0.11975D-01   0.71338D-02
Left SA Boom, Extreme end         5070    -0.17381D-02   0.12642D-01   0.13000D-01
Left SA Boom, Extreme end         5070    -0.17381D-02   0.12642D-01   0.13000D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.21567D-02   0.14402D-01  -0.10475D-01   0.46327D-03   0.24713D-03   0.23039D-03

MODE# 27/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.3161       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.14036D-01   0.62271D-01  -0.11702D-01   0.23663D-03   0.87949D-04   0.15396D-03
Top Right RCS Thruster Assembl    1050    -0.14036D-01   0.62271D-01  -0.11702D-01   0.23663D-03   0.87949D-04   0.15396D-03
Top Left RCS Thrusters Assembl    2050     0.11581D-01   0.62056D-01   0.13501D-01   0.24460D-03  -0.39150D-04   0.16997D-03
Top Left RCS Thrusters Assembl    2050     0.11581D-01   0.62056D-01   0.13501D-01   0.24460D-03  -0.39150D-04   0.16997D-03
Bottom Right RCS Thruster Asse    1150    -0.15924D-01  -0.16282D-01  -0.12710D-01  -0.63396D-04  -0.10387D-03   0.22187D-03
Bottom Right RCS Thruster Asse    1150    -0.15924D-01  -0.16282D-01  -0.12710D-01  -0.63396D-04  -0.10387D-03   0.22187D-03
Bottom Left RCS Thrusters Asse    2150     0.15865D-01  -0.15817D-01   0.14548D-01  -0.38202D-04   0.76519D-04   0.19412D-03
Bottom Left RCS Thrusters Asse    2150     0.15865D-01  -0.15817D-01   0.14548D-01  -0.38202D-04   0.76519D-04   0.19412D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.20633D-02  -0.53440D-02  -0.12970D-01   0.27254D-04   0.72259D-05  -0.91795D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.45080D-02  -0.63782D-02   0.45290D-02
Right Solar Array Boom            6070    -0.45080D-02  -0.63782D-02   0.45290D-02
Left SA Boom, Extreme end         5070     0.10462D-01  -0.47219D-02  -0.85103D-02
Left SA Boom, Extreme end         5070     0.10462D-01  -0.47219D-02  -0.85103D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.10192D-02   0.61384D-02   0.57554D-02  -0.21443D-03  -0.10427D-03   0.16043D-03

MODE# 28/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4006       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.15083D-01  -0.16294D-01   0.21193D-02  -0.66984D-04  -0.50917D-04  -0.25879D-03
Top Right RCS Thruster Assembl    1050     0.15083D-01  -0.16294D-01   0.21193D-02  -0.66984D-04  -0.50917D-04  -0.25879D-03
Top Left RCS Thrusters Assembl    2050    -0.15497D-01  -0.15993D-01  -0.28992D-02  -0.82460D-04   0.16090D-03  -0.18343D-03
Top Left RCS Thrusters Assembl    2050    -0.15497D-01  -0.15993D-01  -0.28992D-02  -0.82460D-04   0.16090D-03  -0.18343D-03
Bottom Right RCS Thruster Asse    1150     0.10741D-01  -0.20793D-02   0.25451D-02   0.46918D-04  -0.12478D-04  -0.29249D-03
Bottom Right RCS Thruster Asse    1150     0.10741D-01  -0.20793D-02   0.25451D-02   0.46918D-04  -0.12478D-04  -0.29249D-03
Bottom Left RCS Thrusters Asse    2150    -0.20467D-01  -0.20592D-02  -0.33280D-02   0.48658D-04  -0.23837D-03  -0.15541D-03
Bottom Left RCS Thrusters Asse    2150    -0.20467D-01  -0.20592D-02  -0.33280D-02   0.48658D-04  -0.23837D-03  -0.15541D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.66667D-02   0.19865D-02   0.24711D-02  -0.14086D-04   0.17128D-04  -0.21772D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.70207D-02   0.17813D-02  -0.98349D-03
Right Solar Array Boom            6070    -0.70207D-02   0.17813D-02  -0.98349D-03
Left SA Boom, Extreme end         5070    -0.90049D-02   0.41789D-02   0.25185D-02
Left SA Boom, Extreme end         5070    -0.90049D-02   0.41789D-02   0.25185D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.10852D-02   0.23183D-02  -0.10809D-01   0.82996D-04   0.22608D-03   0.18218D-04

MODE# 29/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4561       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Right RCS Thruster Assembl    1050     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Left RCS Thrusters Assembl    2050    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Top Left RCS Thrusters Assembl    2050    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Bottom Right RCS Thruster Asse    1150     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Right RCS Thruster Asse    1150     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Left RCS Thrusters Asse    2150    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03
Bottom Left RCS Thrusters Asse    2150    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.31485D-02   0.20823D-01   0.48539D-02   0.48023D-04  -0.11767D-03   0.39456D-03

MODE# 30/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.8273       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Right RCS Thruster Assembl    1050    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Left RCS Thrusters Assembl    2050     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Top Left RCS Thrusters Assembl    2050     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Bottom Right RCS Thruster Asse    1150    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Right RCS Thruster Asse    1150    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Left RCS Thrusters Asse    2150     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02
Bottom Left RCS Thrusters Asse    2150     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.26998D-03   0.10382D-02  -0.24181D-02   0.15716D-03   0.20293D-04  -0.14251D-04

MODE# 31/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.5067       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Right RCS Thruster Assembl    1050    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Left RCS Thrusters Assembl    2050     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Top Left RCS Thrusters Assembl    2050     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Bottom Right RCS Thruster Asse    1150    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Right RCS Thruster Asse    1150    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Left RCS Thrusters Asse    2150     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03
Bottom Left RCS Thrusters Asse    2150     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.52544D-02  -0.28136D-01  -0.19374D-01   0.69462D-03   0.27740D-03  -0.96521D-03

MODE# 32/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.3010       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.13029D-01  -0.12136D-02   0.28575D-02   0.43439D-05   0.15896D-03   0.13553D-03
Top Right RCS Thruster Assembl    1050    -0.13029D-01  -0.12136D-02   0.28575D-02   0.43439D-05   0.15896D-03   0.13553D-03
Top Left RCS Thrusters Assembl    2050     0.99166D-02  -0.11831D-02  -0.35707D-04   0.37360D-05  -0.71708D-04   0.20332D-03
Top Left RCS Thrusters Assembl    2050     0.99166D-02  -0.11831D-02  -0.35707D-04   0.37360D-05  -0.71708D-04   0.20332D-03
Bottom Right RCS Thruster Asse    1150     0.53680D-02   0.10464D-02   0.28787D-02   0.86149D-05   0.45084D-04  -0.10090D-03
Bottom Right RCS Thruster Asse    1150     0.53680D-02   0.10464D-02   0.28787D-02   0.86149D-05   0.45084D-04  -0.10090D-03
Bottom Left RCS Thrusters Asse    2150    -0.49376D-02   0.96789D-03  -0.42262D-04   0.47590D-05  -0.54131D-04  -0.59904D-04
Bottom Left RCS Thrusters Asse    2150    -0.49376D-02   0.96789D-03  -0.42262D-04   0.47590D-05  -0.54131D-04  -0.59904D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.26173D-02   0.11105D-03   0.27980D-02  -0.56922D-05  -0.78553D-04  -0.79990D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.25064D-02  -0.37664D-03  -0.76321D-03   0.44506D-04   0.12456D-03   0.10621D-03
Center Habitat Module             9007    -0.25064D-02  -0.37664D-03  -0.76321D-03   0.44506D-04   0.12456D-03   0.10621D-03
Center Habitat Module             9007    -0.25064D-02  -0.37664D-03  -0.76321D-03   0.44506D-04   0.12456D-03   0.10621D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04
Right Boom (Sensor Assembly)      6001     0.42806D-02   0.10459D-03   0.25958D-02  -0.22256D-04  -0.37470D-03  -0.75427D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.28062D-01   0.86729D-05  -0.92887D-02
Right Solar Array Boom            6070    -0.28062D-01   0.86729D-05  -0.92887D-02
Left SA Boom, Extreme end         5070    -0.10588D-01  -0.91131D-05   0.38563D-02
Left SA Boom, Extreme end         5070    -0.10588D-01  -0.91131D-05   0.38563D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.55739D-03  -0.10265D-02  -0.93706D-03   0.74284D-04   0.96854D-05   0.73054D-04

MODE# 33/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.6158       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Right RCS Thruster Assembl    1050     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Left RCS Thrusters Assembl    2050    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Top Left RCS Thrusters Assembl    2050    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Bottom Right RCS Thruster Asse    1150     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Right RCS Thruster Asse    1150     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Left RCS Thrusters Asse    2150     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05
Bottom Left RCS Thrusters Asse    2150     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.24741D-02   0.14001D-01  -0.53449D-02  -0.38579D-03   0.11357D-03   0.36721D-03

MODE# 34/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.2010       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Right RCS Thruster Assembl    1050     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Left RCS Thrusters Assembl    2050    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Top Left RCS Thrusters Assembl    2050    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Bottom Right RCS Thruster Asse    1150     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Right RCS Thruster Asse    1150     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Left RCS Thrusters Asse    2150    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03
Bottom Left RCS Thrusters Asse    2150    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.13367D-01   0.10809D-02   0.26664D-01  -0.20114D-03   0.46546D-04  -0.12775D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.46806D-02  -0.43565D-03   0.46398D-02
Right Solar Array Boom            6070    -0.46806D-02  -0.43565D-03   0.46398D-02
Left SA Boom, Extreme end         5070     0.13990D-01   0.47949D-02  -0.65422D-02
Left SA Boom, Extreme end         5070     0.13990D-01   0.47949D-02  -0.65422D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.96058D-02   0.92243D-02  -0.11756D-01   0.85290D-03   0.15622D-05   0.61819D-03
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : From All 3
Space Station with RCS and a Double-Gimbal CMG Array (Rigid), From All 3 Axes     
! 34 Flex Modes were selected from all directions. Same Modes as in Previous Examples. The 6 Rigid  
! Modes were not included                                                                           

MODE#  1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.0097       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.59628D-02  -0.16325D-04   0.96510D-04   0.42971D-06  -0.33256D-04   0.10894D-04
Top Right RCS Thruster Assembl    1050     0.59628D-02  -0.16325D-04   0.96510D-04   0.42971D-06  -0.33256D-04   0.10894D-04
Top Left RCS Thrusters Assembl    2050     0.54261D-02  -0.62395D-05   0.74506D-04  -0.10905D-06  -0.31918D-04  -0.18344D-04
Top Left RCS Thrusters Assembl    2050     0.54261D-02  -0.62395D-05   0.74506D-04  -0.10905D-06  -0.31918D-04  -0.18344D-04
Bottom Right RCS Thruster Asse    1150    -0.35170D-02  -0.59190D-04   0.96566D-04   0.13160D-06  -0.31650D-04   0.15942D-04
Bottom Right RCS Thruster Asse    1150    -0.35170D-02  -0.59190D-04   0.96566D-04   0.13160D-06  -0.31650D-04   0.15942D-04
Bottom Left RCS Thrusters Asse    2150    -0.32580D-02  -0.58408D-04   0.74465D-04   0.21757D-06  -0.30306D-04  -0.12670D-04
Bottom Left RCS Thrusters Asse    2150    -0.32580D-02  -0.58408D-04   0.74465D-04   0.21757D-06  -0.30306D-04  -0.12670D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.11384D-02  -0.58736D-04   0.96470D-04  -0.23552D-06  -0.30827D-04   0.65746D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07
Center Habitat Module             9007     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07
Center Habitat Module             9007     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)      6001    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.25921D-01  -0.73995D-04  -0.57584D-04
Right Solar Array Boom            6070    -0.25921D-01  -0.73995D-04  -0.57584D-04
Left SA Boom, Extreme end         5070    -0.26691D-01   0.68332D-05  -0.15103D-03
Left SA Boom, Extreme end         5070    -0.26691D-01   0.68332D-05  -0.15103D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.28820D-02  -0.73445D-04   0.35876D-03   0.49346D-06  -0.54146D-05  -0.28216D-06

MODE#  2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.0255       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.16636D-02   0.23609D-02   0.16364D-03   0.27920D-05  -0.16210D-06  -0.20244D-04
Top Right RCS Thruster Assembl    1050     0.16636D-02   0.23609D-02   0.16364D-03   0.27920D-05  -0.16210D-06  -0.20244D-04
Top Left RCS Thrusters Assembl    2050    -0.11290D-02   0.23621D-02  -0.89259D-04   0.27349D-05  -0.22105D-05  -0.20206D-04
Top Left RCS Thrusters Assembl    2050    -0.11290D-02   0.23621D-02  -0.89259D-04   0.27349D-05  -0.22105D-05  -0.20206D-04
Bottom Right RCS Thruster Asse    1150     0.14025D-02   0.14285D-02   0.16128D-03   0.20836D-05  -0.18388D-05  -0.21107D-04
Bottom Right RCS Thruster Asse    1150     0.14025D-02   0.14285D-02   0.16128D-03   0.20836D-05  -0.18388D-05  -0.21107D-04
Bottom Left RCS Thrusters Asse    2150    -0.15075D-02   0.14276D-02  -0.86874D-04   0.20426D-05  -0.21293D-06  -0.20942D-04
Bottom Left RCS Thrusters Asse    2150    -0.15075D-02   0.14276D-02  -0.86874D-04   0.20426D-05  -0.21293D-06  -0.20942D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.16243D-02   0.18219D-02   0.16059D-03   0.37075D-05  -0.69558D-06  -0.16075D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04
Center Habitat Module             9007     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04
Center Habitat Module             9007     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)      6001     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.47651D-02   0.18134D-02   0.16250D-02
Right Solar Array Boom            6070     0.47651D-02   0.18134D-02   0.16250D-02
Left SA Boom, Extreme end         5070    -0.42523D-02   0.18158D-02  -0.18308D-02
Left SA Boom, Extreme end         5070    -0.42523D-02   0.18158D-02  -0.18308D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.30520D-03   0.69682D-03   0.13621D-03  -0.13573D-05  -0.19247D-05  -0.29404D-04

MODE#  3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.1385       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.21520D-01   0.11996D-03   0.20542D-03   0.19540D-05  -0.12114D-03   0.26882D-04
Top Right RCS Thruster Assembl    1050     0.21520D-01   0.11996D-03   0.20542D-03   0.19540D-05  -0.12114D-03   0.26882D-04
Top Left RCS Thrusters Assembl    2050     0.19134D-01   0.15590D-03   0.68635D-04   0.21893D-06  -0.11507D-03  -0.59819D-04
Top Left RCS Thrusters Assembl    2050     0.19134D-01   0.15590D-03   0.68635D-04   0.21893D-06  -0.11507D-03  -0.59819D-04
Bottom Right RCS Thruster Asse    1150    -0.12744D-01  -0.17813D-03   0.20551D-03   0.20752D-05  -0.11410D-03   0.50047D-04
Bottom Right RCS Thruster Asse    1150    -0.12744D-01  -0.17813D-03   0.20551D-03   0.20752D-05  -0.11410D-03   0.50047D-04
Bottom Left RCS Thrusters Asse    2150    -0.11483D-01  -0.21760D-03   0.68576D-04   0.13666D-06  -0.10779D-03  -0.33796D-04
Bottom Left RCS Thrusters Asse    2150    -0.11483D-01  -0.21760D-03   0.68576D-04   0.13666D-06  -0.10779D-03  -0.33796D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.40181D-02  -0.20058D-04   0.20510D-03  -0.19664D-05  -0.11022D-03   0.19217D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06
Center Habitat Module             9007     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06
Center Habitat Module             9007     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)      6001     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.84761D-01  -0.23417D-04  -0.17658D-02
Right Solar Array Boom            6070    -0.84761D-01  -0.23417D-04  -0.17658D-02
Left SA Boom, Extreme end         5070    -0.87937D-01  -0.32226D-04  -0.25058D-02
Left SA Boom, Extreme end         5070    -0.87937D-01  -0.32226D-04  -0.25058D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.95692D-02  -0.19903D-03   0.46251D-03   0.21385D-05  -0.26851D-05  -0.13445D-05

MODE#  4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2538       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.14977D-02   0.43879D-03   0.15863D-03   0.10564D-05  -0.41345D-05  -0.22571D-04
Top Right RCS Thruster Assembl    1050     0.14977D-02   0.43879D-03   0.15863D-03   0.10564D-05  -0.41345D-05  -0.22571D-04
Top Left RCS Thrusters Assembl    2050    -0.17326D-02   0.38784D-03  -0.13343D-03   0.35465D-05   0.70093D-05  -0.21115D-04
Top Left RCS Thrusters Assembl    2050    -0.17326D-02   0.38784D-03  -0.13343D-03   0.35465D-05   0.70093D-05  -0.21115D-04
Bottom Right RCS Thruster Asse    1150    -0.13642D-02  -0.28102D-03   0.15852D-03   0.10677D-05  -0.41788D-05   0.21874D-04
Bottom Right RCS Thruster Asse    1150    -0.13642D-02  -0.28102D-03   0.15852D-03   0.10677D-05  -0.41788D-05   0.21874D-04
Bottom Left RCS Thrusters Asse    2150     0.19555D-02  -0.23169D-03  -0.13330D-03   0.34632D-05   0.71946D-05   0.23281D-04
Bottom Left RCS Thrusters Asse    2150     0.19555D-02  -0.23169D-03  -0.13330D-03   0.34632D-05   0.71946D-05   0.23281D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.70262D-04   0.78376D-04   0.15821D-03   0.61854D-05  -0.18467D-04  -0.30878D-05

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05
Center Habitat Module             9007    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05
Center Habitat Module             9007    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)      6001     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.11135D-02   0.77862D-04   0.40662D-02
Right Solar Array Boom            6070     0.11135D-02   0.77862D-04   0.40662D-02
Left SA Boom, Extreme end         5070     0.11659D-02   0.70474D-04   0.32605D-02
Left SA Boom, Extreme end         5070     0.11659D-02   0.70474D-04   0.32605D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.22082D-03   0.23081D-04   0.22118D-03   0.39973D-05  -0.98563D-05   0.12769D-05

MODE#  5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2560       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.37349D-02  -0.25508D-03  -0.77408D-04   0.86584D-05   0.18294D-04  -0.71532D-05
Top Right RCS Thruster Assembl    1050    -0.37349D-02  -0.25508D-03  -0.77408D-04   0.86584D-05   0.18294D-04  -0.71532D-05
Top Left RCS Thrusters Assembl    2050    -0.43950D-02   0.92241D-04  -0.80463D-04  -0.83148D-05   0.19591D-04  -0.23596D-05
Top Left RCS Thrusters Assembl    2050    -0.43950D-02   0.92241D-04  -0.80463D-04  -0.83148D-05   0.19591D-04  -0.23596D-05
Bottom Right RCS Thruster Asse    1150     0.70928D-03  -0.62136D-04  -0.77070D-04   0.84158D-05   0.14588D-04  -0.21060D-05
Bottom Right RCS Thruster Asse    1150     0.70928D-03  -0.62136D-04  -0.77070D-04   0.84158D-05   0.14588D-04  -0.21060D-05
Bottom Left RCS Thrusters Asse    2150     0.74699D-03  -0.39800D-03  -0.80821D-04  -0.78968D-05   0.15763D-04   0.22032D-05
Bottom Left RCS Thrusters Asse    2150     0.74699D-03  -0.39800D-03  -0.80821D-04  -0.78968D-05   0.15763D-04   0.22032D-05

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.13200D-02  -0.17334D-03  -0.77745D-04  -0.27079D-04   0.12276D-04  -0.12158D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05
Center Habitat Module             9007    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05
Center Habitat Module             9007    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)      6001    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.37620D-02  -0.16761D-03  -0.24578D-01
Right Solar Array Boom            6070     0.37620D-02  -0.16761D-03  -0.24578D-01
Left SA Boom, Extreme end         5070     0.35787D-02  -0.11463D-03  -0.25536D-01
Left SA Boom, Extreme end         5070     0.35787D-02  -0.11463D-03  -0.25536D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.32285D-03  -0.23092D-03  -0.19637D-02  -0.13880D-05   0.70075D-04  -0.19967D-05

MODE#  6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2724       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.25094D-02  -0.53751D-03  -0.72885D-04  -0.11269D-05   0.13908D-05  -0.38244D-04
Top Right RCS Thruster Assembl    1050     0.25094D-02  -0.53751D-03  -0.72885D-04  -0.11269D-05   0.13908D-05  -0.38244D-04
Top Left RCS Thrusters Assembl    2050    -0.25847D-02  -0.57763D-03  -0.64538D-04   0.83348D-06   0.19435D-05  -0.38585D-04
Top Left RCS Thrusters Assembl    2050    -0.25847D-02  -0.57763D-03  -0.64538D-04   0.83348D-06   0.19435D-05  -0.38585D-04
Bottom Right RCS Thruster Asse    1150     0.31036D-02  -0.61407D-03  -0.71777D-04  -0.75748D-06   0.27646D-05  -0.39131D-04
Bottom Right RCS Thruster Asse    1150     0.31036D-02  -0.61407D-03  -0.71777D-04  -0.75748D-06   0.27646D-05  -0.39131D-04
Bottom Left RCS Thrusters Asse    2150    -0.21025D-02  -0.57532D-03  -0.65659D-04   0.11240D-05   0.17549D-05  -0.39250D-04
Bottom Left RCS Thrusters Asse    2150    -0.21025D-02  -0.57532D-03  -0.65659D-04   0.11240D-05   0.17549D-05  -0.39250D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.27086D-02  -0.53892D-03  -0.72511D-04   0.34288D-05   0.17716D-05  -0.35293D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04
Center Habitat Module             9007     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04
Center Habitat Module             9007     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)      6001     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10629D-01  -0.54165D-03   0.30329D-02
Right Solar Array Boom            6070     0.10629D-01  -0.54165D-03   0.30329D-02
Left SA Boom, Extreme end         5070    -0.10597D-01  -0.54799D-03   0.26902D-02
Left SA Boom, Extreme end         5070    -0.10597D-01  -0.54799D-03   0.26902D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.37323D-03  -0.22865D-02  -0.51211D-04  -0.79422D-06  -0.29755D-05  -0.43171D-04

MODE#  7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2905       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.10428D-01   0.23320D-03  -0.90669D-03  -0.85122D-05   0.70948D-04  -0.10066D-04
Top Right RCS Thruster Assembl    1050    -0.10428D-01   0.23320D-03  -0.90669D-03  -0.85122D-05   0.70948D-04  -0.10066D-04
Top Left RCS Thrusters Assembl    2050    -0.92193D-02  -0.99763D-04  -0.86461D-03   0.77509D-05   0.68353D-04   0.26814D-04
Top Left RCS Thrusters Assembl    2050    -0.92193D-02  -0.99763D-04  -0.86461D-03   0.77509D-05   0.68353D-04   0.26814D-04
Bottom Right RCS Thruster Asse    1150     0.99710D-02   0.80726D-04  -0.90722D-03  -0.83225D-05   0.71850D-04  -0.19963D-04
Bottom Right RCS Thruster Asse    1150     0.99710D-02   0.80726D-04  -0.90722D-03  -0.83225D-05   0.71850D-04  -0.19963D-04
Bottom Left RCS Thrusters Asse    2150     0.95555D-02   0.40312D-03  -0.86426D-03   0.73322D-05   0.68797D-04   0.14665D-04
Bottom Left RCS Thrusters Asse    2150     0.95555D-02   0.40312D-03  -0.86426D-03   0.73322D-05   0.68797D-04   0.14665D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.27553D-03   0.16845D-03  -0.90551D-03   0.26039D-04   0.62764D-04  -0.79699D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05
Center Habitat Module             9007    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05
Center Habitat Module             9007    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)      6001     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.40195D-01   0.16692D-03   0.22993D-01
Right Solar Array Boom            6070     0.40195D-01   0.16692D-03   0.22993D-01
Left SA Boom, Extreme end         5070     0.42191D-01   0.10951D-03   0.23745D-01
Left SA Boom, Extreme end         5070     0.42191D-01   0.10951D-03   0.23745D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.25831D-02   0.26793D-03  -0.17573D-02  -0.16295D-06  -0.36426D-05   0.18950D-05

MODE#  8/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2972       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13523D-01  -0.12229D-02   0.35921D-02   0.31475D-04  -0.97408D-04  -0.81528D-05
Top Right RCS Thruster Assembl    1050     0.13523D-01  -0.12229D-02   0.35921D-02   0.31475D-04  -0.97408D-04  -0.81528D-05
Top Left RCS Thrusters Assembl    2050     0.13171D-01   0.95444D-04   0.37043D-02  -0.32934D-04  -0.98884D-04   0.28602D-05
Top Left RCS Thrusters Assembl    2050     0.13171D-01   0.95444D-04   0.37043D-02  -0.32934D-04  -0.98884D-04   0.28602D-05
Bottom Right RCS Thruster Asse    1150    -0.14040D-01   0.68308D-04   0.35941D-02   0.30606D-04  -0.10083D-03  -0.13868D-04
Bottom Right RCS Thruster Asse    1150    -0.14040D-01   0.68308D-04   0.35941D-02   0.30606D-04  -0.10083D-03  -0.13868D-04
Bottom Left RCS Thrusters Asse    2150    -0.14999D-01  -0.12052D-02   0.37031D-02  -0.31214D-04  -0.10144D-03   0.39493D-06
Bottom Left RCS Thrusters Asse    2150    -0.14999D-01  -0.12052D-02   0.37031D-02  -0.31214D-04  -0.10144D-03   0.39493D-06

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.81986D-04  -0.63207D-03   0.35878D-02  -0.10523D-03  -0.80440D-04  -0.34210D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05
Center Habitat Module             9007    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05
Center Habitat Module             9007    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)      6001     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.16152D-01  -0.60789D-03  -0.92556D-01
Right Solar Array Boom            6070     0.16152D-01  -0.60789D-03  -0.92556D-01
Left SA Boom, Extreme end         5070     0.13509D-01  -0.40151D-03  -0.94027D-01
Left SA Boom, Extreme end         5070     0.13509D-01  -0.40151D-03  -0.94027D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.10092D-02  -0.70457D-03   0.71454D-02  -0.33947D-05   0.95791D-05  -0.47374D-05

MODE#  9/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.9041       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.48484D-01  -0.54011D-02  -0.16731D-01  -0.37220D-04  -0.40283D-03  -0.27094D-04
Top Right RCS Thruster Assembl    1050     0.48484D-01  -0.54011D-02  -0.16731D-01  -0.37220D-04  -0.40283D-03  -0.27094D-04
Top Left RCS Thrusters Assembl    2050     0.43990D-01  -0.56347D-02  -0.12502D-01  -0.25997D-04  -0.41377D-03  -0.33536D-04
Top Left RCS Thrusters Assembl    2050     0.43990D-01  -0.56347D-02  -0.12502D-01  -0.25997D-04  -0.41377D-03  -0.33536D-04
Bottom Right RCS Thruster Asse    1150    -0.69024D-01   0.20594D-02  -0.16731D-01  -0.35659D-04  -0.49448D-03  -0.55369D-04
Bottom Right RCS Thruster Asse    1150    -0.69024D-01   0.20594D-02  -0.16731D-01  -0.35659D-04  -0.49448D-03  -0.55369D-04
Bottom Left RCS Thrusters Asse    2150    -0.75610D-01   0.22800D-02  -0.12509D-01  -0.25139D-04  -0.48984D-03  -0.31144D-04
Bottom Left RCS Thrusters Asse    2150    -0.75610D-01   0.22800D-02  -0.12509D-01  -0.25139D-04  -0.48984D-03  -0.31144D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.55088D-02  -0.14705D-02  -0.16691D-01   0.29272D-05  -0.28298D-03  -0.40991D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04
Center Habitat Module             9007     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04
Center Habitat Module             9007     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)      6001    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.92888D-02  -0.15132D-02   0.30178D-01
Right Solar Array Boom            6070     0.92888D-02  -0.15132D-02   0.30178D-01
Left SA Boom, Extreme end         5070     0.15541D-01  -0.15722D-02   0.15987D-01
Left SA Boom, Extreme end         5070     0.15541D-01  -0.15722D-02   0.15987D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.68334D-03  -0.30893D-02  -0.34341D-01  -0.64458D-04   0.50412D-03  -0.67055D-04

MODE# 10/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    2.0858       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.10023D-01  -0.35850D-01  -0.94292D-02  -0.17789D-03   0.10901D-03  -0.27763D-03
Top Right RCS Thruster Assembl    1050     0.10023D-01  -0.35850D-01  -0.94292D-02  -0.17789D-03   0.10901D-03  -0.27763D-03
Top Left RCS Thrusters Assembl    2050    -0.30071D-01  -0.35819D-01   0.12400D-01  -0.17959D-03   0.80164D-04  -0.28020D-03
Top Left RCS Thrusters Assembl    2050    -0.30071D-01  -0.35819D-01   0.12400D-01  -0.17959D-03   0.80164D-04  -0.28020D-03
Bottom Right RCS Thruster Asse    1150     0.39367D-01   0.96536D-02  -0.93698D-02  -0.15967D-03   0.11589D-03  -0.29540D-03
Bottom Right RCS Thruster Asse    1150     0.39367D-01   0.96536D-02  -0.93698D-02  -0.15967D-03   0.11589D-03  -0.29540D-03
Bottom Left RCS Thrusters Asse    2150    -0.34230D-02   0.96384D-02   0.12335D-01  -0.16016D-03   0.13290D-03  -0.30038D-03
Bottom Left RCS Thrusters Asse    2150    -0.34230D-02   0.96384D-02   0.12335D-01  -0.16016D-03   0.13290D-03  -0.30038D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.24017D-01  -0.11178D-01  -0.93641D-02  -0.11276D-03   0.67165D-04  -0.14243D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03
Center Habitat Module             9007     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03
Center Habitat Module             9007     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)      6001     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.58119D-01  -0.11392D-01   0.29485D-01
Right Solar Array Boom            6070    -0.58119D-01  -0.11392D-01   0.29485D-01
Left SA Boom, Extreme end         5070     0.52744D-01  -0.11290D-01  -0.33691D-01
Left SA Boom, Extreme end         5070     0.52744D-01  -0.11290D-01  -0.33691D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.52022D-02  -0.26741D-01   0.64394D-02  -0.23191D-03  -0.53257D-04  -0.54769D-03

MODE# 11/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    2.1921       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.89610D-02  -0.57551D-01  -0.24622D-01  -0.39438D-03  -0.21895D-04   0.14892D-03
Top Right RCS Thruster Assembl    1050    -0.89610D-02  -0.57551D-01  -0.24622D-01  -0.39438D-03  -0.21895D-04   0.14892D-03
Top Left RCS Thrusters Assembl    2050     0.12315D-01  -0.57541D-01   0.24273D-01  -0.39542D-03  -0.55672D-05   0.15062D-03
Top Left RCS Thrusters Assembl    2050     0.12315D-01  -0.57541D-01   0.24273D-01  -0.39542D-03  -0.55672D-05   0.15062D-03
Bottom Right RCS Thruster Asse    1150    -0.14784D-01   0.52926D-01  -0.24634D-01  -0.39571D-03  -0.16060D-04   0.18100D-03
Bottom Right RCS Thruster Asse    1150    -0.14784D-01   0.52926D-01  -0.24634D-01  -0.39571D-03  -0.16060D-04   0.18100D-03
Bottom Left RCS Thrusters Asse    2150     0.10988D-01   0.52953D-01   0.24271D-01  -0.39391D-03  -0.14677D-04   0.18006D-03
Bottom Left RCS Thrusters Asse    2150     0.10988D-01   0.52953D-01   0.24271D-01  -0.39391D-03  -0.14677D-04   0.18006D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.11933D-01  -0.22978D-02  -0.24480D-01  -0.27578D-03  -0.18136D-04   0.90617D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03
Center Habitat Module             9007    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03
Center Habitat Module             9007    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)      6001    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.26037D-01  -0.24062D-02   0.63273D-01
Right Solar Array Boom            6070     0.26037D-01  -0.24062D-02   0.63273D-01
Left SA Boom, Extreme end         5070    -0.28041D-01  -0.21711D-02  -0.65793D-01
Left SA Boom, Extreme end         5070    -0.28041D-01  -0.21711D-02  -0.65793D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.25693D-02   0.16821D-01   0.64776D-02  -0.42408D-03  -0.40741D-04   0.29098D-03

MODE# 12/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.0756       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.52895D-01   0.74185D-02   0.75969D-03   0.38694D-04  -0.20796D-03  -0.70841D-03
Top Right RCS Thruster Assembl    1050     0.52895D-01   0.74185D-02   0.75969D-03   0.38694D-04  -0.20796D-03  -0.70841D-03
Top Left RCS Thrusters Assembl    2050    -0.48172D-01   0.74428D-02  -0.24789D-02   0.37535D-04   0.20417D-03  -0.67957D-03
Top Left RCS Thrusters Assembl    2050    -0.48172D-01   0.74428D-02  -0.24789D-02   0.37535D-04   0.20417D-03  -0.67957D-03
Bottom Right RCS Thruster Asse    1150    -0.46593D-01  -0.56516D-02   0.75386D-03   0.36593D-04  -0.20848D-03   0.66162D-03
Bottom Right RCS Thruster Asse    1150    -0.46593D-01  -0.56516D-02   0.75386D-03   0.36593D-04  -0.20848D-03   0.66162D-03
Bottom Left RCS Thrusters Asse    2150     0.51815D-01  -0.56769D-02  -0.24712D-02   0.35280D-04   0.21773D-03   0.69059D-03
Bottom Left RCS Thrusters Asse    2150     0.51815D-01  -0.56769D-02  -0.24712D-02   0.35280D-04   0.21773D-03   0.69059D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.32345D-02   0.65956D-03   0.71006D-03   0.32050D-04  -0.47929D-03  -0.11410D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05
Center Habitat Module             9007    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05
Center Habitat Module             9007    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)      6001     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.27361D-01   0.67385D-03   0.13286D-01
Right Solar Array Boom            6070     0.27361D-01   0.67385D-03   0.13286D-01
Left SA Boom, Extreme end         5070     0.28521D-01   0.68685D-03  -0.11599D-01
Left SA Boom, Extreme end         5070     0.28521D-01   0.68685D-03  -0.11599D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.16703D-02  -0.10699D-02  -0.12817D-02   0.69954D-04  -0.64286D-05   0.66596D-05

MODE# 13/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.4152       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.94391D-02   0.11200D-01  -0.12533D-02   0.41230D-04  -0.33653D-04  -0.10106D-03
Top Right RCS Thruster Assembl    1050     0.94391D-02   0.11200D-01  -0.12533D-02   0.41230D-04  -0.33653D-04  -0.10106D-03
Top Left RCS Thrusters Assembl    2050    -0.11844D-02   0.11329D-01  -0.28415D-02   0.34799D-04  -0.68663D-05  -0.83633D-04
Top Left RCS Thrusters Assembl    2050    -0.11844D-02   0.11329D-01  -0.28415D-02   0.34799D-04  -0.68663D-05  -0.83633D-04
Bottom Right RCS Thruster Asse    1150     0.78951D-01  -0.20763D-03  -0.13276D-02   0.18558D-04   0.66571D-03  -0.20304D-03
Bottom Right RCS Thruster Asse    1150     0.78951D-01  -0.20763D-03  -0.13276D-02   0.18558D-04   0.66571D-03  -0.20304D-03
Bottom Left RCS Thrusters Asse    2150     0.51808D-01  -0.30836D-03  -0.27675D-02   0.13678D-04   0.55160D-03  -0.23243D-03
Bottom Left RCS Thrusters Asse    2150     0.51808D-01  -0.30836D-03  -0.27675D-02   0.13678D-04   0.55160D-03  -0.23243D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.73885D-02   0.32383D-02  -0.13324D-02   0.23858D-04   0.39733D-04  -0.19098D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03
Center Habitat Module             9007    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03
Center Habitat Module             9007    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)      6001     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.14533D-01   0.33289D-02   0.11680D-01
Right Solar Array Boom            6070     0.14533D-01   0.33289D-02   0.11680D-01
Left SA Boom, Extreme end         5070    -0.22738D-01   0.34691D-02   0.15481D-01
Left SA Boom, Extreme end         5070    -0.22738D-01   0.34691D-02   0.15481D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.20138D-02   0.52070D-02   0.52933D-02  -0.66245D-04  -0.13102D-03   0.11198D-03

MODE# 14/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.4305       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.37109D-01   0.12551D-01  -0.20035D-02   0.77904D-04  -0.38630D-03   0.19223D-03
Top Right RCS Thruster Assembl    1050     0.37109D-01   0.12551D-01  -0.20035D-02   0.77904D-04  -0.38630D-03   0.19223D-03
Top Left RCS Thrusters Assembl    2050     0.61238D-01   0.12729D-01  -0.63322D-02   0.69130D-04  -0.48218D-03   0.18594D-03
Top Left RCS Thrusters Assembl    2050     0.61238D-01   0.12729D-01  -0.63322D-02   0.69130D-04  -0.48218D-03   0.18594D-03
Bottom Right RCS Thruster Asse    1150     0.19108D-01  -0.25557D-01  -0.19012D-02   0.10699D-03   0.18133D-03   0.45269D-04
Bottom Right RCS Thruster Asse    1150     0.19108D-01  -0.25557D-01  -0.19012D-02   0.10699D-03   0.18133D-03   0.45269D-04
Bottom Left RCS Thrusters Asse    2150     0.24644D-01  -0.25726D-01  -0.64322D-02   0.98580D-04   0.18287D-03   0.53285D-04
Bottom Left RCS Thrusters Asse    2150     0.24644D-01  -0.25726D-01  -0.64322D-02   0.98580D-04   0.18287D-03   0.53285D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.29848D-03  -0.35494D-02  -0.21238D-02   0.92490D-04   0.18383D-04   0.41086D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03
Center Habitat Module             9007    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03
Center Habitat Module             9007    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)      6001    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.13564D-01  -0.36593D-02  -0.10645D-01
Right Solar Array Boom            6070    -0.13564D-01  -0.36593D-02  -0.10645D-01
Left SA Boom, Extreme end         5070     0.55886D-02  -0.36294D-02   0.11115D-03
Left SA Boom, Extreme end         5070     0.55886D-02  -0.36294D-02   0.11115D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.35398D-02  -0.12702D-02   0.52898D-02  -0.21172D-03  -0.14578D-03  -0.41600D-04

MODE# 15/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.5128       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.79555D-01   0.12043D-01   0.57402D-02   0.48800D-04   0.79964D-03  -0.24364D-03
Top Right RCS Thruster Assembl    1050    -0.79555D-01   0.12043D-01   0.57402D-02   0.48800D-04   0.79964D-03  -0.24364D-03
Top Left RCS Thrusters Assembl    2050    -0.11077D+00   0.11824D-01   0.29289D-02   0.59885D-04   0.93769D-03  -0.23210D-03
Top Left RCS Thrusters Assembl    2050    -0.11077D+00   0.11824D-01   0.29289D-02   0.59885D-04   0.93769D-03  -0.23210D-03
Bottom Right RCS Thruster Asse    1150    -0.97108D-01  -0.12162D-01   0.57573D-02   0.53230D-04  -0.89336D-03   0.90630D-04
Bottom Right RCS Thruster Asse    1150    -0.97108D-01  -0.12162D-01   0.57573D-02   0.53230D-04  -0.89336D-03   0.90630D-04
Bottom Left RCS Thrusters Asse    2150    -0.83967D-01  -0.11987D-01   0.29239D-02   0.61667D-04  -0.79724D-03   0.10989D-03
Bottom Left RCS Thrusters Asse    2150    -0.83967D-01  -0.11987D-01   0.29239D-02   0.61667D-04  -0.79724D-03   0.10989D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.20095D-02   0.28153D-03   0.55770D-02   0.77710D-04  -0.52410D-04   0.91932D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04
Center Habitat Module             9007     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04
Center Habitat Module             9007     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)      6001    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10901D-01   0.34770D-03  -0.38313D-02
Right Solar Array Boom            6070     0.10901D-01   0.34770D-03  -0.38313D-02
Left SA Boom, Extreme end         5070     0.11667D-01   0.60814D-04   0.21169D-02
Left SA Boom, Extreme end         5070     0.11667D-01   0.60814D-04   0.21169D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.80156D-02   0.30977D-03  -0.30834D-02  -0.89602D-04   0.17651D-03   0.22645D-04

MODE# 16/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.7999       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.11047D-01  -0.35352D-02  -0.47226D-04  -0.52024D-05   0.63971D-04   0.83297D-04
Top Right RCS Thruster Assembl    1050    -0.11047D-01  -0.35352D-02  -0.47226D-04  -0.52024D-05   0.63971D-04   0.83297D-04
Top Left RCS Thrusters Assembl    2050     0.82160D-03  -0.34829D-02   0.60132D-04  -0.77263D-05   0.37535D-04   0.91522D-04
Top Left RCS Thrusters Assembl    2050     0.82160D-03  -0.34829D-02   0.60132D-04  -0.77263D-05   0.37535D-04   0.91522D-04
Bottom Right RCS Thruster Asse    1150    -0.57479D-02  -0.75279D-02   0.49875D-04   0.23218D-04  -0.99919D-05   0.10030D-03
Bottom Right RCS Thruster Asse    1150    -0.57479D-02  -0.75279D-02   0.49875D-04   0.23218D-04  -0.99919D-05   0.10030D-03
Bottom Left RCS Thrusters Asse    2150     0.75436D-02  -0.75839D-02  -0.36094D-04   0.20485D-04   0.25349D-04   0.96172D-04
Bottom Left RCS Thrusters Asse    2150     0.75436D-02  -0.75839D-02  -0.36094D-04   0.20485D-04   0.25349D-04   0.96172D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.39857D-02  -0.26781D-02  -0.26579D-04   0.60022D-05  -0.76494D-06   0.57508D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.30296D-03  -0.30433D-02   0.20606D-03  -0.45198D-05  -0.59983D-05   0.71387D-04
Center Habitat Module             9007    -0.30296D-03  -0.30433D-02   0.20606D-03  -0.45198D-05  -0.59983D-05   0.71387D-04
Center Habitat Module             9007    -0.30296D-03  -0.30433D-02   0.20606D-03  -0.45198D-05  -0.59983D-05   0.71387D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.49033D-02  -0.26962D-02   0.32629D-04   0.44543D-05  -0.33426D-04   0.46436D-04
Right Boom (Sensor Assembly)      6001    -0.49033D-02  -0.26962D-02   0.32629D-04   0.44543D-05  -0.33426D-04   0.46436D-04
Right Boom (Sensor Assembly)      6001    -0.49033D-02  -0.26962D-02   0.32629D-04   0.44543D-05  -0.33426D-04   0.46436D-04
