Right Boom (Sensor Assembly)      6001    -0.49033D-02  -0.26962D-02   0.32629D-04   0.44543D-05  -0.33426D-04   0.46436D-04
Right Boom (Sensor Assembly)      6001    -0.49033D-02  -0.26962D-02   0.32629D-04   0.44543D-05  -0.33426D-04   0.46436D-04
Right Boom (Sensor Assembly)      6001    -0.49033D-02  -0.26962D-02   0.32629D-04   0.44543D-05  -0.33426D-04   0.46436D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.76125D-02  -0.27851D-02   0.72102D-03
Right Solar Array Boom            6070     0.76125D-02  -0.27851D-02   0.72102D-03
Left SA Boom, Extreme end         5070    -0.80350D-02  -0.28093D-02   0.16452D-02
Left SA Boom, Extreme end         5070    -0.80350D-02  -0.28093D-02   0.16452D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.50514D-03  -0.61730D-03   0.64700D-03  -0.12899D-04  -0.42941D-05   0.39341D-04

MODE# 17/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.9226       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.68027D-01  -0.11097D-01  -0.60073D-03  -0.18784D-04   0.38210D-03   0.59560D-03
Top Right RCS Thruster Assembl    1050    -0.68027D-01  -0.11097D-01  -0.60073D-03  -0.18784D-04   0.38210D-03   0.59560D-03
Top Left RCS Thrusters Assembl    2050     0.15719D-01  -0.10836D-01   0.21226D-03  -0.31526D-04   0.15490D-03   0.64920D-03
Top Left RCS Thrusters Assembl    2050     0.15719D-01  -0.10836D-01   0.21226D-03  -0.31526D-04   0.15490D-03   0.64920D-03
Bottom Right RCS Thruster Asse    1150    -0.38865D-01  -0.22662D-01  -0.28607D-03   0.72619D-04  -0.99520D-04   0.65039D-03
Bottom Right RCS Thruster Asse    1150    -0.38865D-01  -0.22662D-01  -0.28607D-03   0.72619D-04  -0.99520D-04   0.65039D-03
Bottom Left RCS Thrusters Asse    2150     0.46401D-01  -0.22909D-01  -0.10021D-03   0.60730D-04   0.14944D-03   0.62682D-03
Bottom Left RCS Thrusters Asse    2150     0.46401D-01  -0.22909D-01  -0.10021D-03   0.60730D-04   0.14944D-03   0.62682D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.24274D-01  -0.76881D-02  -0.52700D-03   0.99422D-05   0.75584D-05   0.40000D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03
Center Habitat Module             9007     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03
Center Habitat Module             9007     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)      6001    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.43648D-01  -0.79705D-02   0.50741D-02
Right Solar Array Boom            6070     0.43648D-01  -0.79705D-02   0.50741D-02
Left SA Boom, Extreme end         5070    -0.45818D-01  -0.79181D-02   0.72136D-02
Left SA Boom, Extreme end         5070    -0.45818D-01  -0.79181D-02   0.72136D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.42233D-03   0.17769D-02   0.34600D-02  -0.90323D-04  -0.28463D-04  -0.13222D-04

MODE# 18/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.4863       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.12875D+00   0.15846D-01   0.55651D-02   0.39161D-04  -0.10362D-02  -0.10072D-02
Top Right RCS Thruster Assembl    1050     0.12875D+00   0.15846D-01   0.55651D-02   0.39161D-04  -0.10362D-02  -0.10072D-02
Top Left RCS Thrusters Assembl    2050    -0.32509D-01   0.14805D-01   0.53426D-02   0.90456D-04  -0.21360D-03  -0.12130D-02
Top Left RCS Thrusters Assembl    2050    -0.32509D-01   0.14805D-01   0.53426D-02   0.90456D-04  -0.21360D-03  -0.12130D-02
Bottom Right RCS Thruster Asse    1150    -0.65770D-01  -0.23675D-01   0.56940D-02   0.76696D-04  -0.10275D-03   0.13657D-02
Bottom Right RCS Thruster Asse    1150    -0.65770D-01  -0.23675D-01   0.56940D-02   0.76696D-04  -0.10275D-03   0.13657D-02
Bottom Left RCS Thrusters Asse    2150     0.11669D+00  -0.22746D-01   0.52406D-02   0.12158D-03   0.85956D-03   0.11811D-02
Bottom Left RCS Thrusters Asse    2150     0.11669D+00  -0.22746D-01   0.52406D-02   0.12158D-03   0.85956D-03   0.11811D-02

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.14368D-01  -0.38438D-03   0.52613D-02   0.13964D-03  -0.53080D-03   0.20124D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04
Center Habitat Module             9007     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04
Center Habitat Module             9007     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)      6001    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.35863D-02  -0.24037D-03  -0.98177D-02
Right Solar Array Boom            6070     0.35863D-02  -0.24037D-03  -0.98177D-02
Left SA Boom, Extreme end         5070    -0.58629D-02  -0.95077D-03   0.32684D-02
Left SA Boom, Extreme end         5070    -0.58629D-02  -0.95077D-03   0.32684D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.19313D-02  -0.39475D-03  -0.22370D-01  -0.15734D-04   0.53522D-03   0.29696D-04

MODE# 19/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.5992       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.35489D-01   0.40465D-02  -0.71263D-02   0.94151D-04   0.15992D-03  -0.10318D-02
Top Right RCS Thruster Assembl    1050     0.35489D-01   0.40465D-02  -0.71263D-02   0.94151D-04   0.15992D-03  -0.10318D-02
Top Left RCS Thrusters Assembl    2050    -0.10799D+00   0.63293D-02  -0.11353D-01  -0.17864D-04   0.90498D-03  -0.10038D-02
Top Left RCS Thrusters Assembl    2050    -0.10799D+00   0.63293D-02  -0.11353D-01  -0.17864D-04   0.90498D-03  -0.10038D-02
Bottom Right RCS Thruster Asse    1150    -0.66434D-01   0.11081D-01  -0.73336D-02   0.29057D-04  -0.51139D-03   0.88277D-03
Bottom Right RCS Thruster Asse    1150    -0.66434D-01   0.11081D-01  -0.73336D-02   0.29057D-04  -0.51139D-03   0.88277D-03
Bottom Left RCS Thrusters Asse    2150     0.58740D-01   0.90101D-02  -0.11168D-01  -0.71120D-04   0.19154D-03   0.86892D-03
Bottom Left RCS Thrusters Asse    2150     0.58740D-01   0.90101D-02  -0.11168D-01  -0.71120D-04   0.19154D-03   0.86892D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.17826D-01   0.13912D-02  -0.70242D-02  -0.18719D-03  -0.46324D-03  -0.86245D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05
Center Habitat Module             9007    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05
Center Habitat Module             9007    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)      6001     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.32736D-01   0.12239D-02   0.16424D-02
Right Solar Array Boom            6070    -0.32736D-01   0.12239D-02   0.16424D-02
Left SA Boom, Extreme end         5070    -0.10665D-01   0.24529D-02   0.10979D-01
Left SA Boom, Extreme end         5070    -0.10665D-01   0.24529D-02   0.10979D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.20330D-02  -0.19804D-02   0.34808D-01   0.16183D-03  -0.82006D-03  -0.16494D-04

MODE# 20/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.8706       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.10166D-01   0.55559D-02  -0.35086D-02   0.66138D-04  -0.12932D-03   0.38520D-03
Top Right RCS Thruster Assembl    1050    -0.10166D-01   0.55559D-02  -0.35086D-02   0.66138D-04  -0.12932D-03   0.38520D-03
Top Left RCS Thrusters Assembl    2050     0.37110D-01   0.80357D-02   0.20079D-02  -0.54793D-04  -0.40651D-03   0.29075D-03
Top Left RCS Thrusters Assembl    2050     0.37110D-01   0.80357D-02   0.20079D-02  -0.54793D-04  -0.40651D-03   0.29075D-03
Bottom Right RCS Thruster Asse    1150     0.48378D-01  -0.20154D-01  -0.32853D-02   0.12552D-03   0.49666D-03  -0.39437D-03
Bottom Right RCS Thruster Asse    1150     0.48378D-01  -0.20154D-01  -0.32853D-02   0.12552D-03   0.49666D-03  -0.39437D-03
Bottom Left RCS Thrusters Asse    2150    -0.14009D-01  -0.22487D-01   0.17893D-02   0.13474D-04   0.14959D-03  -0.49262D-03
Bottom Left RCS Thrusters Asse    2150    -0.14009D-01  -0.22487D-01   0.17893D-02   0.13474D-04   0.14959D-03  -0.49262D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.12830D-01  -0.12610D-02  -0.36183D-02  -0.12977D-03   0.12042D-03   0.20158D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04
Center Habitat Module             9007     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04
Center Habitat Module             9007     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)      6001    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.71227D-02  -0.14500D-02   0.50761D-02
Right Solar Array Boom            6070     0.71227D-02  -0.14500D-02   0.50761D-02
Left SA Boom, Extreme end         5070     0.28862D-01  -0.95600D-03   0.26536D-02
Left SA Boom, Extreme end         5070     0.28862D-01  -0.95600D-03   0.26536D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.30943D-02   0.10332D-02  -0.70041D-02  -0.16435D-03   0.45275D-03   0.26820D-05

MODE# 21/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.0593       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.64135D-01   0.17686D-01  -0.90872D-02   0.44338D-05   0.48330D-03   0.66404D-03
Top Right RCS Thruster Assembl    1050    -0.64135D-01   0.17686D-01  -0.90872D-02   0.44338D-05   0.48330D-03   0.66404D-03
Top Left RCS Thrusters Assembl    2050     0.37836D-01   0.17449D-01   0.68641D-02   0.14993D-04  -0.86378D-04   0.76334D-03
Top Left RCS Thrusters Assembl    2050     0.37836D-01   0.17449D-01   0.68641D-02   0.14993D-04  -0.86378D-04   0.76334D-03
Bottom Right RCS Thruster Asse    1150     0.45700D-01  -0.86457D-01  -0.79814D-02   0.32345D-03   0.17287D-03  -0.81678D-03
Bottom Right RCS Thruster Asse    1150     0.45700D-01  -0.86457D-01  -0.79814D-02   0.32345D-03   0.17287D-03  -0.81678D-03
Bottom Left RCS Thrusters Asse    2150    -0.63494D-01  -0.86177D-01   0.57908D-02   0.33757D-03  -0.47135D-03  -0.72030D-03
Bottom Left RCS Thrusters Asse    2150    -0.63494D-01  -0.86177D-01   0.57908D-02   0.33757D-03  -0.47135D-03  -0.72030D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.56265D-02  -0.27607D-02  -0.94191D-02   0.16288D-03   0.24700D-03  -0.62282D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04
Center Habitat Module             9007    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04
Center Habitat Module             9007    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)      6001     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.97172D-02  -0.30777D-02  -0.20018D-02
Right Solar Array Boom            6070    -0.97172D-02  -0.30777D-02  -0.20018D-02
Left SA Boom, Extreme end         5070    -0.13932D-01  -0.28919D-02   0.13844D-02
Left SA Boom, Extreme end         5070    -0.13932D-01  -0.28919D-02   0.13844D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.62297D-03   0.54326D-02   0.13679D-01  -0.40427D-03  -0.26375D-03   0.44312D-04

MODE# 22/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.2068       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.39253D-01   0.35520D-01   0.11600D-01   0.26881D-03   0.16026D-03   0.60709D-03
Top Right RCS Thruster Assembl    1050    -0.39253D-01   0.35520D-01   0.11600D-01   0.26881D-03   0.16026D-03   0.60709D-03
Top Left RCS Thrusters Assembl    2050     0.41310D-01   0.35526D-01  -0.12223D-01   0.26966D-03  -0.30022D-03   0.52858D-03
Top Left RCS Thrusters Assembl    2050     0.41310D-01   0.35526D-01  -0.12223D-01   0.26966D-03  -0.30022D-03   0.52858D-03
Bottom Right RCS Thruster Asse    1150     0.47244D-01   0.81086D-01   0.97195D-02  -0.28146D-03   0.37806D-03  -0.57104D-03
Bottom Right RCS Thruster Asse    1150     0.47244D-01   0.81086D-01   0.97195D-02  -0.28146D-03   0.37806D-03  -0.57104D-03
Bottom Left RCS Thrusters Asse    2150    -0.38862D-01   0.81046D-01  -0.10346D-01  -0.28441D-03  -0.14958D-03  -0.65453D-03
Bottom Left RCS Thrusters Asse    2150    -0.38862D-01   0.81046D-01  -0.10346D-01  -0.28441D-03  -0.14958D-03  -0.65453D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.72411D-02   0.39069D-02   0.11128D-01  -0.10709D-03   0.16699D-03   0.25213D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03
Center Habitat Module             9007     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03
Center Habitat Module             9007     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)      6001    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10201D-01   0.43630D-02   0.52541D-03
Right Solar Array Boom            6070     0.10201D-01   0.43630D-02   0.52541D-03
Left SA Boom, Extreme end         5070     0.10040D-01   0.43201D-02   0.50684D-03
Left SA Boom, Extreme end         5070     0.10040D-01   0.43201D-02   0.50684D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.12916D-02  -0.59701D-02  -0.11698D-02   0.59213D-03  -0.12150D-03  -0.66394D-04

MODE# 23/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.5116       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.40177D-03  -0.42331D-01  -0.58481D-02  -0.21296D-03  -0.51175D-04   0.94598D-04
Top Right RCS Thruster Assembl    1050     0.40177D-03  -0.42331D-01  -0.58481D-02  -0.21296D-03  -0.51175D-04   0.94598D-04
Top Left RCS Thrusters Assembl    2050    -0.49628D-02  -0.41859D-01  -0.20127D-02  -0.23692D-03  -0.77488D-05  -0.17003D-03
Top Left RCS Thrusters Assembl    2050    -0.49628D-02  -0.41859D-01  -0.20127D-02  -0.23692D-03  -0.77488D-05  -0.17003D-03
Bottom Right RCS Thruster Asse    1150     0.28412D-02  -0.34238D-01  -0.45031D-02   0.17861D-03   0.17629D-03   0.27900D-03
Bottom Right RCS Thruster Asse    1150     0.28412D-02  -0.34238D-01  -0.45031D-02   0.17861D-03   0.17629D-03   0.27900D-03
Bottom Left RCS Thrusters Asse    2150     0.20851D-01  -0.34584D-01  -0.33787D-02   0.16201D-03   0.28328D-03  -0.28374D-04
Bottom Left RCS Thrusters Asse    2150     0.20851D-01  -0.34584D-01  -0.33787D-02   0.16201D-03   0.28328D-03  -0.28374D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.87343D-02   0.27891D-03  -0.50462D-02  -0.31898D-04  -0.81319D-04   0.61494D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module             9007     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)      6001    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.31374D-01   0.41582D-03   0.36196D-02
Right Solar Array Boom            6070     0.31374D-01   0.41582D-03   0.36196D-02
Left SA Boom, Extreme end         5070     0.27577D-01   0.63939D-03   0.56146D-03
Left SA Boom, Extreme end         5070     0.27577D-01   0.63939D-03   0.56146D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.28518D-02   0.34118D-02   0.34718D-01  -0.70970D-04  -0.81304D-03   0.42532D-04

MODE# 24/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.7113       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.69217D-03  -0.21677D-01  -0.46064D-03  -0.10020D-03  -0.40916D-04   0.73097D-04
Top Right RCS Thruster Assembl    1050    -0.69217D-03  -0.21677D-01  -0.46064D-03  -0.10020D-03  -0.40916D-04   0.73097D-04
Top Left RCS Thrusters Assembl    2050     0.22853D-02  -0.21465D-01  -0.17503D-02  -0.11064D-03  -0.55212D-04  -0.30785D-04
Top Left RCS Thrusters Assembl    2050     0.22853D-02  -0.21465D-01  -0.17503D-02  -0.11064D-03  -0.55212D-04  -0.30785D-04
Bottom Right RCS Thruster Asse    1150     0.42646D-02  -0.85364D-02   0.10306D-03   0.63965D-04   0.10612D-03   0.62742D-04
Bottom Right RCS Thruster Asse    1150     0.42646D-02  -0.85364D-02   0.10306D-03   0.63965D-04   0.10612D-03   0.62742D-04
Bottom Left RCS Thrusters Asse    2150     0.51422D-02  -0.87098D-02  -0.23245D-02   0.55493D-04   0.10770D-03  -0.54696D-04
Bottom Left RCS Thrusters Asse    2150     0.51422D-02  -0.87098D-02  -0.23245D-02   0.55493D-04   0.10770D-03  -0.54696D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.51490D-02   0.94482D-03  -0.42733D-04  -0.23534D-04  -0.18934D-04   0.23184D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module             9007     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)      6001    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.21090D-01   0.11246D-02   0.46533D-02
Right Solar Array Boom            6070     0.21090D-01   0.11246D-02   0.46533D-02
Left SA Boom, Extreme end         5070     0.19900D-01   0.11410D-02  -0.27416D-02
Left SA Boom, Extreme end         5070     0.19900D-01   0.11410D-02  -0.27416D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.12812D-02   0.14499D-02   0.95570D-02   0.32066D-04  -0.22681D-03   0.21264D-04

MODE# 25/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.8636       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.67316D-02  -0.51642D-01   0.20506D-01  -0.40685D-03  -0.97960D-05  -0.15696D-03
Top Right RCS Thruster Assembl    1050     0.67316D-02  -0.51642D-01   0.20506D-01  -0.40685D-03  -0.97960D-05  -0.15696D-03
Top Left RCS Thrusters Assembl    2050    -0.13585D-01  -0.57622D-01   0.12198D-01  -0.11413D-03   0.12355D-03  -0.15253D-03
Top Left RCS Thrusters Assembl    2050    -0.13585D-01  -0.57622D-01   0.12198D-01  -0.11413D-03   0.12355D-03  -0.15253D-03
Bottom Right RCS Thruster Asse    1150     0.14106D-01  -0.28345D-01   0.22147D-01   0.77478D-04   0.11670D-03  -0.18385D-03
Bottom Right RCS Thruster Asse    1150     0.14106D-01  -0.28345D-01   0.22147D-01   0.77478D-04   0.11670D-03  -0.18385D-03
Bottom Left RCS Thrusters Asse    2150    -0.92732D-02  -0.22786D-01   0.10622D-01   0.34499D-03  -0.41981D-04  -0.16955D-03
Bottom Left RCS Thrusters Asse    2150    -0.92732D-02  -0.22786D-01   0.10622D-01   0.34499D-03  -0.41981D-04  -0.16955D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.15887D-02   0.61989D-02   0.21124D-01   0.37013D-03  -0.41712D-04  -0.67442D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module             9007    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)      6001     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.11780D-01   0.78112D-02  -0.19425D-01
Right Solar Array Boom            6070    -0.11780D-01   0.78112D-02  -0.19425D-01
Left SA Boom, Extreme end         5070     0.81602D-02   0.56711D-02  -0.18170D-01
Left SA Boom, Extreme end         5070     0.81602D-02   0.56711D-02  -0.18170D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.44448D-03   0.34497D-02  -0.13690D-01   0.26188D-03   0.35467D-04   0.54371D-04

MODE# 26/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.9866       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.84824D-02  -0.10133D+00   0.10125D-02  -0.39854D-03  -0.12155D-03  -0.91410D-04
Top Right RCS Thruster Assembl    1050     0.84824D-02  -0.10133D+00   0.10125D-02  -0.39854D-03  -0.12155D-03  -0.91410D-04
Top Left RCS Thrusters Assembl    2050     0.17181D-02  -0.98201D-01  -0.16214D-01  -0.54990D-03  -0.37841D-04  -0.51754D-04
Top Left RCS Thrusters Assembl    2050     0.17181D-02  -0.98201D-01  -0.16214D-01  -0.54990D-03  -0.37841D-04  -0.51754D-04
Bottom Right RCS Thruster Asse    1150     0.83208D-02  -0.37563D-01   0.38653D-02   0.43039D-03   0.56903D-04  -0.23350D-03
Bottom Right RCS Thruster Asse    1150     0.83208D-02  -0.37563D-01   0.38653D-02   0.43039D-03   0.56903D-04  -0.23350D-03
Bottom Left RCS Thrusters Asse    2150    -0.15025D-01  -0.40611D-01  -0.19120D-01   0.28162D-03  -0.14576D-03  -0.15038D-03
Bottom Left RCS Thrusters Asse    2150    -0.15025D-01  -0.40611D-01  -0.19120D-01   0.28162D-03  -0.14576D-03  -0.15038D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.24720D-02   0.10916D-01   0.31714D-02  -0.29072D-03   0.46370D-04  -0.26743D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module             9007    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)      6001     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.12274D-01   0.11975D-01   0.71338D-02
Right Solar Array Boom            6070    -0.12274D-01   0.11975D-01   0.71338D-02
Left SA Boom, Extreme end         5070    -0.17381D-02   0.12642D-01   0.13000D-01
Left SA Boom, Extreme end         5070    -0.17381D-02   0.12642D-01   0.13000D-01

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.21567D-02   0.14402D-01  -0.10475D-01   0.46327D-03   0.24713D-03   0.23039D-03

MODE# 27/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.3161       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.14036D-01   0.62271D-01  -0.11702D-01   0.23663D-03   0.87949D-04   0.15396D-03
Top Right RCS Thruster Assembl    1050    -0.14036D-01   0.62271D-01  -0.11702D-01   0.23663D-03   0.87949D-04   0.15396D-03
Top Left RCS Thrusters Assembl    2050     0.11581D-01   0.62056D-01   0.13501D-01   0.24460D-03  -0.39150D-04   0.16997D-03
Top Left RCS Thrusters Assembl    2050     0.11581D-01   0.62056D-01   0.13501D-01   0.24460D-03  -0.39150D-04   0.16997D-03
Bottom Right RCS Thruster Asse    1150    -0.15924D-01  -0.16282D-01  -0.12710D-01  -0.63396D-04  -0.10387D-03   0.22187D-03
Bottom Right RCS Thruster Asse    1150    -0.15924D-01  -0.16282D-01  -0.12710D-01  -0.63396D-04  -0.10387D-03   0.22187D-03
Bottom Left RCS Thrusters Asse    2150     0.15865D-01  -0.15817D-01   0.14548D-01  -0.38202D-04   0.76519D-04   0.19412D-03
Bottom Left RCS Thrusters Asse    2150     0.15865D-01  -0.15817D-01   0.14548D-01  -0.38202D-04   0.76519D-04   0.19412D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.20633D-02  -0.53440D-02  -0.12970D-01   0.27254D-04   0.72259D-05  -0.91795D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module             9007    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)      6001     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.45080D-02  -0.63782D-02   0.45290D-02
Right Solar Array Boom            6070    -0.45080D-02  -0.63782D-02   0.45290D-02
Left SA Boom, Extreme end         5070     0.10462D-01  -0.47219D-02  -0.85103D-02
Left SA Boom, Extreme end         5070     0.10462D-01  -0.47219D-02  -0.85103D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.10192D-02   0.61384D-02   0.57554D-02  -0.21443D-03  -0.10427D-03   0.16043D-03

MODE# 28/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4006       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.15083D-01  -0.16294D-01   0.21193D-02  -0.66984D-04  -0.50917D-04  -0.25879D-03
Top Right RCS Thruster Assembl    1050     0.15083D-01  -0.16294D-01   0.21193D-02  -0.66984D-04  -0.50917D-04  -0.25879D-03
Top Left RCS Thrusters Assembl    2050    -0.15497D-01  -0.15993D-01  -0.28992D-02  -0.82460D-04   0.16090D-03  -0.18343D-03
Top Left RCS Thrusters Assembl    2050    -0.15497D-01  -0.15993D-01  -0.28992D-02  -0.82460D-04   0.16090D-03  -0.18343D-03
Bottom Right RCS Thruster Asse    1150     0.10741D-01  -0.20793D-02   0.25451D-02   0.46918D-04  -0.12478D-04  -0.29249D-03
Bottom Right RCS Thruster Asse    1150     0.10741D-01  -0.20793D-02   0.25451D-02   0.46918D-04  -0.12478D-04  -0.29249D-03
Bottom Left RCS Thrusters Asse    2150    -0.20467D-01  -0.20592D-02  -0.33280D-02   0.48658D-04  -0.23837D-03  -0.15541D-03
Bottom Left RCS Thrusters Asse    2150    -0.20467D-01  -0.20592D-02  -0.33280D-02   0.48658D-04  -0.23837D-03  -0.15541D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.66667D-02   0.19865D-02   0.24711D-02  -0.14086D-04   0.17128D-04  -0.21772D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module             9007    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)      6001     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.70207D-02   0.17813D-02  -0.98349D-03
Right Solar Array Boom            6070    -0.70207D-02   0.17813D-02  -0.98349D-03
Left SA Boom, Extreme end         5070    -0.90049D-02   0.41789D-02   0.25185D-02
Left SA Boom, Extreme end         5070    -0.90049D-02   0.41789D-02   0.25185D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.10852D-02   0.23183D-02  -0.10809D-01   0.82996D-04   0.22608D-03   0.18218D-04

MODE# 29/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4561       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Right RCS Thruster Assembl    1050     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Left RCS Thrusters Assembl    2050    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Top Left RCS Thrusters Assembl    2050    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Bottom Right RCS Thruster Asse    1150     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Right RCS Thruster Asse    1150     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Left RCS Thrusters Asse    2150    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03
Bottom Left RCS Thrusters Asse    2150    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module             9007    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)      6001    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Right Solar Array Boom            6070     0.16018D-02   0.28662D-02   0.95619D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02
Left SA Boom, Extreme end         5070     0.59330D-02   0.44159D-02  -0.59648D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.31485D-02   0.20823D-01   0.48539D-02   0.48023D-04  -0.11767D-03   0.39456D-03

MODE# 30/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.8273       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Right RCS Thruster Assembl    1050    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Left RCS Thrusters Assembl    2050     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Top Left RCS Thrusters Assembl    2050     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Bottom Right RCS Thruster Asse    1150    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Right RCS Thruster Asse    1150    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Left RCS Thrusters Asse    2150     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02
Bottom Left RCS Thrusters Asse    2150     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module             9007    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)      6001     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Right Solar Array Boom            6070    -0.17123D-01   0.38936D-02   0.20893D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02
Left SA Boom, Extreme end         5070     0.16946D-01   0.47593D-02  -0.31958D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.26998D-03   0.10382D-02  -0.24181D-02   0.15716D-03   0.20293D-04  -0.14251D-04

MODE# 31/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.5067       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Right RCS Thruster Assembl    1050    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Left RCS Thrusters Assembl    2050     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Top Left RCS Thrusters Assembl    2050     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Bottom Right RCS Thruster Asse    1150    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Right RCS Thruster Asse    1150    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Left RCS Thrusters Asse    2150     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03
Bottom Left RCS Thrusters Asse    2150     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module             9007     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)      6001     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Right Solar Array Boom            6070     0.10825D-01   0.12631D-01   0.10387D-01
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02
Left SA Boom, Extreme end         5070    -0.94460D-02   0.17142D-01  -0.68973D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.52544D-02  -0.28136D-01  -0.19374D-01   0.69462D-03   0.27740D-03  -0.96521D-03

MODE# 32/ 51, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.4150       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050    -0.34577D-02  -0.25538D-02   0.17986D-01   0.13026D-03  -0.52134D-04   0.11134D-03
Top Right RCS Thruster Assembl    1050    -0.34577D-02  -0.25538D-02   0.17986D-01   0.13026D-03  -0.52134D-04   0.11134D-03
Top Left RCS Thrusters Assembl    2050     0.11287D-01  -0.16182D-02  -0.99253D-02   0.89821D-04  -0.27574D-03   0.16790D-03
Top Left RCS Thrusters Assembl    2050     0.11287D-01  -0.16182D-02  -0.99253D-02   0.89821D-04  -0.27574D-03   0.16790D-03
Bottom Right RCS Thruster Asse    1150    -0.12183D-02  -0.34289D-02   0.18359D-01   0.20858D-03   0.31081D-04   0.33678D-04
Bottom Right RCS Thruster Asse    1150    -0.12183D-02  -0.34289D-02   0.18359D-01   0.20858D-03   0.31081D-04   0.33678D-04
Bottom Left RCS Thrusters Asse    2150     0.34645D-02  -0.43587D-02  -0.10176D-01   0.16219D-03   0.14839D-03   0.83215D-04
Bottom Left RCS Thrusters Asse    2150     0.34645D-02  -0.43587D-02  -0.10176D-01   0.16219D-03   0.14839D-03   0.83215D-04

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.36308D-02   0.30770D-02   0.17629D-01  -0.21670D-03   0.26746D-04  -0.44555D-04

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.13092D-01  -0.76273D-03   0.78456D-02   0.67138D-03   0.10868D-02   0.60264D-03
Center Habitat Module             9007    -0.13092D-01  -0.76273D-03   0.78456D-02   0.67138D-03   0.10868D-02   0.60264D-03
Center Habitat Module             9007    -0.13092D-01  -0.76273D-03   0.78456D-02   0.67138D-03   0.10868D-02   0.60264D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04
Right Boom (Sensor Assembly)      6001    -0.36094D-02   0.30893D-02   0.10240D-01  -0.44014D-03   0.68272D-04  -0.12316D-04

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070     0.62030D-02   0.27544D-02   0.77558D-02
Right Solar Array Boom            6070     0.62030D-02   0.27544D-02   0.77558D-02
Left SA Boom, Extreme end         5070    -0.12188D-01   0.60682D-02  -0.13195D-03
Left SA Boom, Extreme end         5070    -0.12188D-01   0.60682D-02  -0.13195D-03

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018    -0.74549D-02  -0.20683D-01  -0.51404D-02   0.83666D-03   0.36612D-04   0.19586D-03

MODE# 33/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.6158       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Right RCS Thruster Assembl    1050     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Left RCS Thrusters Assembl    2050    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Top Left RCS Thrusters Assembl    2050    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Bottom Right RCS Thruster Asse    1150     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Right RCS Thruster Asse    1150     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Left RCS Thrusters Asse    2150     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05
Bottom Left RCS Thrusters Asse    2150     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module             9007    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)      6001    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Right Solar Array Boom            6070    -0.72630D-02  -0.53016D-02  -0.25077D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02
Left SA Boom, Extreme end         5070     0.36650D-02  -0.20268D-02  -0.65125D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.24741D-02   0.14001D-01  -0.53449D-02  -0.38579D-03   0.11357D-03   0.36721D-03

MODE# 34/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.2010       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  8 Engines, (x,y,z)...
Top Right RCS Thruster Assembl    1050     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Right RCS Thruster Assembl    1050     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Left RCS Thrusters Assembl    2050    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Top Left RCS Thrusters Assembl    2050    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Bottom Right RCS Thruster Asse    1150     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Right RCS Thruster Asse    1150     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Left RCS Thrusters Asse    2150    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03
Bottom Left RCS Thrusters Asse    2150    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03

                              Node ID#     Modal Data at the Double Gimbal GMGs Cluster...
Right Keel/Boom Intrsect, CMG     1000    -0.13367D-01   0.10809D-02   0.26664D-01  -0.20114D-03   0.46546D-04  -0.12775D-03

                              Node ID#     Modal Data at the  3 External Torque Points...
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module             9007    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)      6001    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03

                              Node ID#     Modal Data at the  4 Accelerometers, along (x,y,z)...
Right Solar Array Boom            6070    -0.46806D-02  -0.43565D-03   0.46398D-02
Right Solar Array Boom            6070    -0.46806D-02  -0.43565D-03   0.46398D-02
Left SA Boom, Extreme end         5070     0.13990D-01   0.47949D-02  -0.65422D-02
Left SA Boom, Extreme end         5070     0.13990D-01   0.47949D-02  -0.65422D-02

                              Node ID#     Modal Data at the Disturbance Point 
Module, (Front Dock)              9018     0.96058D-02   0.92243D-02  -0.11756D-01   0.85290D-03   0.15622D-05   0.61819D-03
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Station with RCS and a Double-Gimbal CMG Array (Flex)
System
vehicle_flex34
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Station with RCS and a Double-Gimbal CMG Array (Rigid)
System
vehicle_rigid
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
