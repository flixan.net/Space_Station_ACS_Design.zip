Bottom Left RCS Thrusters Asse      28    -0.83967D-01  -0.11987D-01   0.29239D-02   0.61667D-04  -0.79724D-03   0.10989D-03
Center Habitat Module               21     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04
Center Habitat Module               21     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04
Center Habitat Module               21     0.74814D-02   0.11866D-02   0.16631D-02  -0.17692D-03  -0.33971D-03   0.62347D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.20095D-02   0.28153D-03   0.55770D-02   0.77710D-04  -0.52410D-04   0.91932D-04
Right Keel/Boom Intrsect, CMG       10    -0.20095D-02   0.28153D-03   0.55770D-02   0.77710D-04  -0.52410D-04   0.91932D-04
Right Keel/Boom Intrsect, CMG       10    -0.20095D-02   0.28153D-03   0.55770D-02   0.77710D-04  -0.52410D-04   0.91932D-04
Payload boom, (top-right)            1    -0.93037D-01   0.12768D-01   0.57553D-02   0.37511D-04   0.81068D-03  -0.27166D-03
Payload boom, (top-right)            1    -0.93037D-01   0.12768D-01   0.57553D-02   0.37511D-04   0.81068D-03  -0.27166D-03
Payload boom, (top-right)            1    -0.93037D-01   0.12768D-01   0.57553D-02   0.37511D-04   0.81068D-03  -0.27166D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)         9    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)         9    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Solar Array Boom               5     0.10901D-01   0.34770D-03  -0.38313D-02  -0.14815D-03  -0.39152D-03  -0.16484D-03
Right Solar Array Boom               5     0.10901D-01   0.34770D-03  -0.38313D-02  -0.14815D-03  -0.39152D-03  -0.16484D-03
Left SA Boom, Extreeme End          18     0.11667D-01   0.60814D-04   0.21169D-02  -0.14966D-04  -0.26842D-03   0.30446D-03
Left SA Boom, Extreeme End          18     0.11667D-01   0.60814D-04   0.21169D-02  -0.14966D-04  -0.26842D-03   0.30446D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)         9    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Right Boom (Sensor Assembly)         9    -0.33439D-02   0.28764D-03   0.68802D-02   0.69166D-04  -0.87358D-04   0.69890D-04
Bottom Payload Boom (Left) Ant      24    -0.97412D-01  -0.12938D-01   0.29114D-02   0.48649D-04  -0.80680D-03   0.13435D-03
Bottom Payload Boom (Left) Ant      24    -0.97412D-01  -0.12938D-01   0.29114D-02   0.48649D-04  -0.80680D-03   0.13435D-03
Bottom Payload Boom (Left) Ant      24    -0.97412D-01  -0.12938D-01   0.29114D-02   0.48649D-04  -0.80680D-03   0.13435D-03
Right SA Boom, Outboard the Hi       7    -0.43400D-02   0.31021D-03   0.89666D-02  -0.65326D-04  -0.21509D-03  -0.91676D-04
Left SA Boom, Outboard the Hin      16    -0.15748D-01   0.80964D-04   0.10497D-02  -0.46324D-06  -0.50632D-04   0.14426D-03

MODE# 22/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.9226       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.68027D-01  -0.11097D-01  -0.60073D-03  -0.18784D-04   0.38210D-03   0.59560D-03
Top Right RCS Thruster Assembl      25    -0.68027D-01  -0.11097D-01  -0.60073D-03  -0.18784D-04   0.38210D-03   0.59560D-03
Top Left RCS Thrusters Assembl      26     0.15719D-01  -0.10836D-01   0.21226D-03  -0.31526D-04   0.15490D-03   0.64920D-03
Top Left RCS Thrusters Assembl      26     0.15719D-01  -0.10836D-01   0.21226D-03  -0.31526D-04   0.15490D-03   0.64920D-03
Bottom Right RCS Thruster Asse      27    -0.38865D-01  -0.22662D-01  -0.28607D-03   0.72619D-04  -0.99520D-04   0.65039D-03
Bottom Right RCS Thruster Asse      27    -0.38865D-01  -0.22662D-01  -0.28607D-03   0.72619D-04  -0.99520D-04   0.65039D-03
Bottom Left RCS Thrusters Asse      28     0.46401D-01  -0.22909D-01  -0.10021D-03   0.60730D-04   0.14944D-03   0.62682D-03
Bottom Left RCS Thrusters Asse      28     0.46401D-01  -0.22909D-01  -0.10021D-03   0.60730D-04   0.14944D-03   0.62682D-03
Center Habitat Module               21     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03
Center Habitat Module               21     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03
Center Habitat Module               21     0.40788D-02  -0.95084D-02   0.10222D-02   0.17136D-05  -0.33025D-04  -0.30274D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.24274D-01  -0.76881D-02  -0.52700D-03   0.99422D-05   0.75584D-05   0.40000D-03
Right Keel/Boom Intrsect, CMG       10    -0.24274D-01  -0.76881D-02  -0.52700D-03   0.99422D-05   0.75584D-05   0.40000D-03
Right Keel/Boom Intrsect, CMG       10    -0.24274D-01  -0.76881D-02  -0.52700D-03   0.99422D-05   0.75584D-05   0.40000D-03
Payload boom, (top-right)            1    -0.74320D-01  -0.11373D-01  -0.60858D-03  -0.13127D-04   0.37422D-03   0.62454D-03
Payload boom, (top-right)            1    -0.74320D-01  -0.11373D-01  -0.60858D-03  -0.13127D-04   0.37422D-03   0.62454D-03
Payload boom, (top-right)            1    -0.74320D-01  -0.11373D-01  -0.60858D-03  -0.13127D-04   0.37422D-03   0.62454D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)         9    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)         9    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Solar Array Boom               5     0.43648D-01  -0.79705D-02   0.50741D-02   0.56286D-04  -0.10848D-02  -0.88973D-03
Right Solar Array Boom               5     0.43648D-01  -0.79705D-02   0.50741D-02   0.56286D-04  -0.10848D-02  -0.88973D-03
Left SA Boom, Extreeme End          18    -0.45818D-01  -0.79181D-02   0.72136D-02  -0.10846D-03  -0.10830D-02  -0.94852D-03
Left SA Boom, Extreeme End          18    -0.45818D-01  -0.79181D-02   0.72136D-02  -0.10846D-03  -0.10830D-02  -0.94852D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)         9    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Right Boom (Sensor Assembly)         9    -0.30833D-01  -0.77427D-02  -0.56012D-03   0.53652D-05  -0.16483D-03   0.33726D-03
Bottom Payload Boom (Left) Ant      24     0.48789D-01  -0.23773D-01  -0.12732D-03   0.37436D-04   0.13927D-03   0.65454D-03
Bottom Payload Boom (Left) Ant      24     0.48789D-01  -0.23773D-01  -0.12732D-03   0.37436D-04   0.13927D-03   0.65454D-03
Bottom Payload Boom (Left) Ant      24     0.48789D-01  -0.23773D-01  -0.12732D-03   0.37436D-04   0.13927D-03   0.65454D-03
Right SA Boom, Outboard the Hi       7    -0.37738D-01  -0.78856D-02   0.65093D-04   0.36140D-04  -0.61577D-03  -0.46499D-03
Left SA Boom, Outboard the Hin      16     0.40886D-01  -0.78285D-02  -0.21183D-02  -0.52235D-04  -0.63623D-03  -0.49440D-03

MODE# 23/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.4863       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.12875D+00   0.15846D-01   0.55651D-02   0.39161D-04  -0.10362D-02  -0.10072D-02
Top Right RCS Thruster Assembl      25     0.12875D+00   0.15846D-01   0.55651D-02   0.39161D-04  -0.10362D-02  -0.10072D-02
Top Left RCS Thrusters Assembl      26    -0.32509D-01   0.14805D-01   0.53426D-02   0.90456D-04  -0.21360D-03  -0.12130D-02
Top Left RCS Thrusters Assembl      26    -0.32509D-01   0.14805D-01   0.53426D-02   0.90456D-04  -0.21360D-03  -0.12130D-02
Bottom Right RCS Thruster Asse      27    -0.65770D-01  -0.23675D-01   0.56940D-02   0.76696D-04  -0.10275D-03   0.13657D-02
Bottom Right RCS Thruster Asse      27    -0.65770D-01  -0.23675D-01   0.56940D-02   0.76696D-04  -0.10275D-03   0.13657D-02
Bottom Left RCS Thrusters Asse      28     0.11669D+00  -0.22746D-01   0.52406D-02   0.12158D-03   0.85956D-03   0.11811D-02
Bottom Left RCS Thrusters Asse      28     0.11669D+00  -0.22746D-01   0.52406D-02   0.12158D-03   0.85956D-03   0.11811D-02
Center Habitat Module               21     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04
Center Habitat Module               21     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04
Center Habitat Module               21     0.15003D-02  -0.11982D-03   0.70391D-02  -0.25366D-04  -0.87355D-04   0.18296D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.14368D-01  -0.38438D-03   0.52613D-02   0.13964D-03  -0.53080D-03   0.20124D-03
Right Keel/Boom Intrsect, CMG       10    -0.14368D-01  -0.38438D-03   0.52613D-02   0.13964D-03  -0.53080D-03   0.20124D-03
Right Keel/Boom Intrsect, CMG       10    -0.14368D-01  -0.38438D-03   0.52613D-02   0.13964D-03  -0.53080D-03   0.20124D-03
Payload boom, (top-right)            1     0.14556D+00   0.16319D-01   0.55940D-02   0.19723D-04  -0.10032D-02  -0.11598D-02
Payload boom, (top-right)            1     0.14556D+00   0.16319D-01   0.55940D-02   0.19723D-04  -0.10032D-02  -0.11598D-02
Payload boom, (top-right)            1     0.14556D+00   0.16319D-01   0.55940D-02   0.19723D-04  -0.10032D-02  -0.11598D-02

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)         9    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)         9    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Solar Array Boom               5     0.35863D-02  -0.24037D-03  -0.98177D-02  -0.26286D-03   0.95508D-03  -0.38704D-03
Right Solar Array Boom               5     0.35863D-02  -0.24037D-03  -0.98177D-02  -0.26286D-03   0.95508D-03  -0.38704D-03
Left SA Boom, Extreeme End          18    -0.58629D-02  -0.95077D-03   0.32684D-02   0.10083D-03  -0.16135D-02   0.27042D-03
Left SA Boom, Extreeme End          18    -0.58629D-02  -0.95077D-03   0.32684D-02   0.10083D-03  -0.16135D-02   0.27042D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)         9    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Right Boom (Sensor Assembly)         9    -0.18533D-01  -0.37880D-03   0.75313D-02   0.12569D-03  -0.42821D-03   0.22259D-03
Bottom Payload Boom (Left) Ant      24     0.13046D+00  -0.24619D-01   0.52070D-02   0.85231D-04   0.81912D-03   0.13453D-02
Bottom Payload Boom (Left) Ant      24     0.13046D+00  -0.24619D-01   0.52070D-02   0.85231D-04   0.81912D-03   0.13453D-02
Bottom Payload Boom (Left) Ant      24     0.13046D+00  -0.24619D-01   0.52070D-02   0.85231D-04   0.81912D-03   0.13453D-02
Right SA Boom, Outboard the Hi       7    -0.28734D-01  -0.33822D-03   0.11869D-01  -0.10182D-03   0.71008D-04  -0.12106D-03
Left SA Boom, Outboard the Hin      16    -0.27325D-01  -0.92603D-03   0.10992D-01   0.15173D-04  -0.17623D-03   0.48667D-04

MODE# 24/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.5992       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.35489D-01   0.40465D-02  -0.71263D-02   0.94151D-04   0.15992D-03  -0.10318D-02
Top Right RCS Thruster Assembl      25     0.35489D-01   0.40465D-02  -0.71263D-02   0.94151D-04   0.15992D-03  -0.10318D-02
Top Left RCS Thrusters Assembl      26    -0.10799D+00   0.63293D-02  -0.11353D-01  -0.17864D-04   0.90498D-03  -0.10038D-02
Top Left RCS Thrusters Assembl      26    -0.10799D+00   0.63293D-02  -0.11353D-01  -0.17864D-04   0.90498D-03  -0.10038D-02
Bottom Right RCS Thruster Asse      27    -0.66434D-01   0.11081D-01  -0.73336D-02   0.29057D-04  -0.51139D-03   0.88277D-03
Bottom Right RCS Thruster Asse      27    -0.66434D-01   0.11081D-01  -0.73336D-02   0.29057D-04  -0.51139D-03   0.88277D-03
Bottom Left RCS Thrusters Asse      28     0.58740D-01   0.90101D-02  -0.11168D-01  -0.71120D-04   0.19154D-03   0.86892D-03
Bottom Left RCS Thrusters Asse      28     0.58740D-01   0.90101D-02  -0.11168D-01  -0.71120D-04   0.19154D-03   0.86892D-03
Center Habitat Module               21    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05
Center Habitat Module               21    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05
Center Habitat Module               21    -0.19890D-02   0.65680D-03  -0.76399D-02   0.13025D-03   0.55330D-04  -0.35744D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.17826D-01   0.13912D-02  -0.70242D-02  -0.18719D-03  -0.46324D-03  -0.86245D-04
Right Keel/Boom Intrsect, CMG       10     0.17826D-01   0.13912D-02  -0.70242D-02  -0.18719D-03  -0.46324D-03  -0.86245D-04
Right Keel/Boom Intrsect, CMG       10     0.17826D-01   0.13912D-02  -0.70242D-02  -0.18719D-03  -0.46324D-03  -0.86245D-04
Payload boom, (top-right)            1     0.32279D-01   0.57100D-02  -0.71303D-02   0.85330D-04   0.19672D-03  -0.11387D-02
Payload boom, (top-right)            1     0.32279D-01   0.57100D-02  -0.71303D-02   0.85330D-04   0.19672D-03  -0.11387D-02
Payload boom, (top-right)            1     0.32279D-01   0.57100D-02  -0.71303D-02   0.85330D-04   0.19672D-03  -0.11387D-02

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)         9     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)         9     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Solar Array Boom               5    -0.32736D-01   0.12239D-02   0.16424D-02   0.34348D-03   0.18845D-02   0.55400D-03
Right Solar Array Boom               5    -0.32736D-01   0.12239D-02   0.16424D-02   0.34348D-03   0.18845D-02   0.55400D-03
Left SA Boom, Extreeme End          18    -0.10665D-01   0.24529D-02   0.10979D-01  -0.39443D-03  -0.39846D-03  -0.25330D-03
Left SA Boom, Extreeme End          18    -0.10665D-01   0.24529D-02   0.10979D-01  -0.39443D-03  -0.39846D-03  -0.25330D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)         9     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Right Boom (Sensor Assembly)         9     0.19563D-01   0.13826D-02  -0.11726D-01  -0.24070D-03  -0.43176D-03  -0.69984D-04
Bottom Payload Boom (Left) Ant      24     0.61495D-01   0.10186D-01  -0.11157D-01  -0.47486D-04   0.15959D-03   0.97039D-03
Bottom Payload Boom (Left) Ant      24     0.61495D-01   0.10186D-01  -0.11157D-01  -0.47486D-04   0.15959D-03   0.97039D-03
Bottom Payload Boom (Left) Ant      24     0.61495D-01   0.10186D-01  -0.11157D-01  -0.47486D-04   0.15959D-03   0.97039D-03
Right SA Boom, Outboard the Hi       7     0.18266D-01   0.13409D-02  -0.24487D-01   0.68465D-04   0.34111D-03   0.32040D-03
Left SA Boom, Outboard the Hin      16     0.12413D-01   0.24674D-02  -0.21756D-01  -0.14694D-03  -0.14792D-03  -0.13615D-03

MODE# 25/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.8706       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.10166D-01   0.55559D-02  -0.35086D-02   0.66138D-04  -0.12932D-03   0.38520D-03
Top Right RCS Thruster Assembl      25    -0.10166D-01   0.55559D-02  -0.35086D-02   0.66138D-04  -0.12932D-03   0.38520D-03
Top Left RCS Thrusters Assembl      26     0.37110D-01   0.80357D-02   0.20079D-02  -0.54793D-04  -0.40651D-03   0.29075D-03
Top Left RCS Thrusters Assembl      26     0.37110D-01   0.80357D-02   0.20079D-02  -0.54793D-04  -0.40651D-03   0.29075D-03
Bottom Right RCS Thruster Asse      27     0.48378D-01  -0.20154D-01  -0.32853D-02   0.12552D-03   0.49666D-03  -0.39437D-03
Bottom Right RCS Thruster Asse      27     0.48378D-01  -0.20154D-01  -0.32853D-02   0.12552D-03   0.49666D-03  -0.39437D-03
Bottom Left RCS Thrusters Asse      28    -0.14009D-01  -0.22487D-01   0.17893D-02   0.13474D-04   0.14959D-03  -0.49262D-03
Bottom Left RCS Thrusters Asse      28    -0.14009D-01  -0.22487D-01   0.17893D-02   0.13474D-04   0.14959D-03  -0.49262D-03
Center Habitat Module               21     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04
Center Habitat Module               21     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04
Center Habitat Module               21     0.30392D-02   0.21583D-02   0.16467D-01  -0.18326D-03  -0.33793D-03   0.32034D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.12830D-01  -0.12610D-02  -0.36183D-02  -0.12977D-03   0.12042D-03   0.20158D-03
Right Keel/Boom Intrsect, CMG       10    -0.12830D-01  -0.12610D-02  -0.36183D-02  -0.12977D-03   0.12042D-03   0.20158D-03
Right Keel/Boom Intrsect, CMG       10    -0.12830D-01  -0.12610D-02  -0.36183D-02  -0.12977D-03   0.12042D-03   0.20158D-03
Payload boom, (top-right)            1    -0.78170D-02   0.66520D-02  -0.34923D-02   0.40318D-04  -0.14317D-03   0.40574D-03
Payload boom, (top-right)            1    -0.78170D-02   0.66520D-02  -0.34923D-02   0.40318D-04  -0.14317D-03   0.40574D-03
Payload boom, (top-right)            1    -0.78170D-02   0.66520D-02  -0.34923D-02   0.40318D-04  -0.14317D-03   0.40574D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)         9    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)         9    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Solar Array Boom               5     0.71227D-02  -0.14500D-02   0.50761D-02   0.30787D-03   0.59303D-03  -0.42118D-03
Right Solar Array Boom               5     0.71227D-02  -0.14500D-02   0.50761D-02   0.30787D-03   0.59303D-03  -0.42118D-03
Left SA Boom, Extreeme End          18     0.28862D-01  -0.95600D-03   0.26536D-02  -0.29449D-03   0.12817D-02   0.61460D-03
Left SA Boom, Extreeme End          18     0.28862D-01  -0.95600D-03   0.26536D-02  -0.29449D-03   0.12817D-02   0.61460D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)         9    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Right Boom (Sensor Assembly)         9    -0.17184D-01  -0.12932D-02  -0.76870D-02  -0.19669D-03  -0.15103D-03   0.23262D-03
Bottom Payload Boom (Left) Ant      24    -0.11262D-01  -0.22385D-01   0.17461D-02  -0.17080D-04   0.16708D-03  -0.52558D-03
Bottom Payload Boom (Left) Ant      24    -0.11262D-01  -0.22385D-01   0.17461D-02  -0.17080D-04   0.16708D-03  -0.52558D-03
Bottom Payload Boom (Left) Ant      24    -0.11262D-01  -0.22385D-01   0.17461D-02  -0.17080D-04   0.16708D-03  -0.52558D-03
Right SA Boom, Outboard the Hi       7    -0.28241D-01  -0.13707D-02  -0.18653D-01   0.69932D-04  -0.13787D-03  -0.13202D-03
Left SA Boom, Outboard the Hin      16    -0.25354D-01  -0.77151D-03  -0.18266D-01  -0.25862D-04   0.17256D-03   0.28762D-03

MODE# 26/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.0593       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.64135D-01   0.17686D-01  -0.90872D-02   0.44338D-05   0.48330D-03   0.66404D-03
Top Right RCS Thruster Assembl      25    -0.64135D-01   0.17686D-01  -0.90872D-02   0.44338D-05   0.48330D-03   0.66404D-03
Top Left RCS Thrusters Assembl      26     0.37836D-01   0.17449D-01   0.68641D-02   0.14993D-04  -0.86378D-04   0.76334D-03
Top Left RCS Thrusters Assembl      26     0.37836D-01   0.17449D-01   0.68641D-02   0.14993D-04  -0.86378D-04   0.76334D-03
Bottom Right RCS Thruster Asse      27     0.45700D-01  -0.86457D-01  -0.79814D-02   0.32345D-03   0.17287D-03  -0.81678D-03
Bottom Right RCS Thruster Asse      27     0.45700D-01  -0.86457D-01  -0.79814D-02   0.32345D-03   0.17287D-03  -0.81678D-03
Bottom Left RCS Thrusters Asse      28    -0.63494D-01  -0.86177D-01   0.57908D-02   0.33757D-03  -0.47135D-03  -0.72030D-03
Bottom Left RCS Thrusters Asse      28    -0.63494D-01  -0.86177D-01   0.57908D-02   0.33757D-03  -0.47135D-03  -0.72030D-03
Center Habitat Module               21    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04
Center Habitat Module               21    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04
Center Habitat Module               21    -0.20433D-02   0.38239D-02  -0.12343D-01  -0.44412D-03   0.10941D-03   0.65976D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.56265D-02  -0.27607D-02  -0.94191D-02   0.16288D-03   0.24700D-03  -0.62282D-04
Right Keel/Boom Intrsect, CMG       10     0.56265D-02  -0.27607D-02  -0.94191D-02   0.16288D-03   0.24700D-03  -0.62282D-04
Right Keel/Boom Intrsect, CMG       10     0.56265D-02  -0.27607D-02  -0.94191D-02   0.16288D-03   0.24700D-03  -0.62282D-04
Payload boom, (top-right)            1    -0.71890D-01   0.17444D-01  -0.90396D-02  -0.41797D-04   0.45971D-03   0.75548D-03
Payload boom, (top-right)            1    -0.71890D-01   0.17444D-01  -0.90396D-02  -0.41797D-04   0.45971D-03   0.75548D-03
Payload boom, (top-right)            1    -0.71890D-01   0.17444D-01  -0.90396D-02  -0.41797D-04   0.45971D-03   0.75548D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)         9     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)         9     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Solar Array Boom               5    -0.97172D-02  -0.30777D-02  -0.20018D-02   0.72932D-04   0.45881D-03   0.21511D-03
Right Solar Array Boom               5    -0.97172D-02  -0.30777D-02  -0.20018D-02   0.72932D-04   0.45881D-03   0.21511D-03
Left SA Boom, Extreeme End          18    -0.13932D-01  -0.28919D-02   0.13844D-02   0.93972D-04  -0.72572D-03  -0.26894D-03
Left SA Boom, Extreeme End          18    -0.13932D-01  -0.28919D-02   0.13844D-02   0.93972D-04  -0.72572D-03  -0.26894D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)         9     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Right Boom (Sensor Assembly)         9     0.69453D-02  -0.28028D-02  -0.83665D-02   0.86902D-04   0.41010D-04  -0.64559D-04
Bottom Payload Boom (Left) Ant      24    -0.71014D-01  -0.90964D-01   0.56205D-02   0.18215D-03  -0.44437D-03  -0.81799D-03
Bottom Payload Boom (Left) Ant      24    -0.71014D-01  -0.90964D-01   0.56205D-02   0.18215D-03  -0.44437D-03  -0.81799D-03
Bottom Payload Boom (Left) Ant      24    -0.71014D-01  -0.90964D-01   0.56205D-02   0.18215D-03  -0.44437D-03  -0.81799D-03
Right SA Boom, Outboard the Hi       7     0.90060D-02  -0.29357D-02  -0.73176D-02   0.28376D-04   0.38524D-04   0.97763D-04
Left SA Boom, Outboard the Hin      16     0.10152D-01  -0.28692D-02   0.88383D-02   0.29467D-04  -0.38450D-04  -0.13373D-03

MODE# 27/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.2068       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.39253D-01   0.35520D-01   0.11600D-01   0.26881D-03   0.16026D-03   0.60709D-03
Top Right RCS Thruster Assembl      25    -0.39253D-01   0.35520D-01   0.11600D-01   0.26881D-03   0.16026D-03   0.60709D-03
Top Left RCS Thrusters Assembl      26     0.41310D-01   0.35526D-01  -0.12223D-01   0.26966D-03  -0.30022D-03   0.52858D-03
Top Left RCS Thrusters Assembl      26     0.41310D-01   0.35526D-01  -0.12223D-01   0.26966D-03  -0.30022D-03   0.52858D-03
Bottom Right RCS Thruster Asse      27     0.47244D-01   0.81086D-01   0.97195D-02  -0.28146D-03   0.37806D-03  -0.57104D-03
Bottom Right RCS Thruster Asse      27     0.47244D-01   0.81086D-01   0.97195D-02  -0.28146D-03   0.37806D-03  -0.57104D-03
Bottom Left RCS Thrusters Asse      28    -0.38862D-01   0.81046D-01  -0.10346D-01  -0.28441D-03  -0.14958D-03  -0.65453D-03
Bottom Left RCS Thrusters Asse      28    -0.38862D-01   0.81046D-01  -0.10346D-01  -0.28441D-03  -0.14958D-03  -0.65453D-03
Center Habitat Module               21     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03
Center Habitat Module               21     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03
Center Habitat Module               21     0.36497D-02  -0.67038D-02   0.71185D-02   0.68941D-03  -0.63983D-05  -0.10199D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.72411D-02   0.39069D-02   0.11128D-01  -0.10709D-03   0.16699D-03   0.25213D-03
Right Keel/Boom Intrsect, CMG       10    -0.72411D-02   0.39069D-02   0.11128D-01  -0.10709D-03   0.16699D-03   0.25213D-03
Right Keel/Boom Intrsect, CMG       10    -0.72411D-02   0.39069D-02   0.11128D-01  -0.10709D-03   0.16699D-03   0.25213D-03
Payload boom, (top-right)            1    -0.41656D-01   0.39903D-01   0.11640D-01   0.23900D-03   0.13975D-03   0.65232D-03
Payload boom, (top-right)            1    -0.41656D-01   0.39903D-01   0.11640D-01   0.23900D-03   0.13975D-03   0.65232D-03
Payload boom, (top-right)            1    -0.41656D-01   0.39903D-01   0.11640D-01   0.23900D-03   0.13975D-03   0.65232D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)         9    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)         9    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Solar Array Boom               5     0.10201D-01   0.43630D-02   0.52541D-03  -0.53486D-04   0.20312D-03  -0.44180D-03
Right Solar Array Boom               5     0.10201D-01   0.43630D-02   0.52541D-03  -0.53486D-04   0.20312D-03  -0.44180D-03
Left SA Boom, Extreeme End          18     0.10040D-01   0.43201D-02   0.50684D-03  -0.42214D-04  -0.24720D-03   0.42198D-03
Left SA Boom, Extreeme End          18     0.10040D-01   0.43201D-02   0.50684D-03  -0.42214D-04  -0.24720D-03   0.42198D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)         9    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Right Boom (Sensor Assembly)         9    -0.12396D-01   0.39589D-02   0.89911D-02  -0.10961D-03  -0.48553D-04   0.28019D-03
Bottom Payload Boom (Left) Ant      24    -0.41050D-01   0.84941D-01  -0.10178D-01  -0.12992D-03  -0.12595D-03  -0.70372D-03
Bottom Payload Boom (Left) Ant      24    -0.41050D-01   0.84941D-01  -0.10178D-01  -0.12992D-03  -0.12595D-03  -0.70372D-03
Bottom Payload Boom (Left) Ant      24    -0.41050D-01   0.84941D-01  -0.10178D-01  -0.12992D-03  -0.12595D-03  -0.70372D-03
Right SA Boom, Outboard the Hi       7    -0.25711D-01   0.41478D-02   0.44073D-02  -0.35870D-04  -0.15436D-03  -0.11939D-03
Left SA Boom, Outboard the Hin      16    -0.24586D-01   0.42544D-02  -0.41115D-02  -0.50838D-04   0.15751D-03   0.11109D-03

MODE# 28/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.5116       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.40177D-03  -0.42331D-01  -0.58481D-02  -0.21296D-03  -0.51175D-04   0.94598D-04
Top Right RCS Thruster Assembl      25     0.40177D-03  -0.42331D-01  -0.58481D-02  -0.21296D-03  -0.51175D-04   0.94598D-04
Top Left RCS Thrusters Assembl      26    -0.49628D-02  -0.41859D-01  -0.20127D-02  -0.23692D-03  -0.77488D-05  -0.17003D-03
Top Left RCS Thrusters Assembl      26    -0.49628D-02  -0.41859D-01  -0.20127D-02  -0.23692D-03  -0.77488D-05  -0.17003D-03
Bottom Right RCS Thruster Asse      27     0.28412D-02  -0.34238D-01  -0.45031D-02   0.17861D-03   0.17629D-03   0.27900D-03
Bottom Right RCS Thruster Asse      27     0.28412D-02  -0.34238D-01  -0.45031D-02   0.17861D-03   0.17629D-03   0.27900D-03
Bottom Left RCS Thrusters Asse      28     0.20851D-01  -0.34584D-01  -0.33787D-02   0.16201D-03   0.28328D-03  -0.28374D-04
Bottom Left RCS Thrusters Asse      28     0.20851D-01  -0.34584D-01  -0.33787D-02   0.16201D-03   0.28328D-03  -0.28374D-04
Center Habitat Module               21     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module               21     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04
Center Habitat Module               21     0.22891D-02   0.23097D-02  -0.16924D-01  -0.12029D-03   0.15487D-03   0.67078D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.87343D-02   0.27891D-03  -0.50462D-02  -0.31898D-04  -0.81319D-04   0.61494D-03
Right Keel/Boom Intrsect, CMG       10    -0.87343D-02   0.27891D-03  -0.50462D-02  -0.31898D-04  -0.81319D-04   0.61494D-03
Right Keel/Boom Intrsect, CMG       10    -0.87343D-02   0.27891D-03  -0.50462D-02  -0.31898D-04  -0.81319D-04   0.61494D-03
Payload boom, (top-right)            1     0.12196D-02  -0.45512D-01  -0.59308D-02  -0.14509D-03  -0.49244D-04   0.36055D-04
Payload boom, (top-right)            1     0.12196D-02  -0.45512D-01  -0.59308D-02  -0.14509D-03  -0.49244D-04   0.36055D-04
Payload boom, (top-right)            1     0.12196D-02  -0.45512D-01  -0.59308D-02  -0.14509D-03  -0.49244D-04   0.36055D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)         9    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)         9    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Solar Array Boom               5     0.31374D-01   0.41582D-03   0.36196D-02   0.10586D-03  -0.36793D-03  -0.10442D-02
Right Solar Array Boom               5     0.31374D-01   0.41582D-03   0.36196D-02   0.10586D-03  -0.36793D-03  -0.10442D-02
Left SA Boom, Extreeme End          18     0.27577D-01   0.63939D-03   0.56146D-03  -0.11033D-03   0.17645D-03   0.96216D-03
Left SA Boom, Extreeme End          18     0.27577D-01   0.63939D-03   0.56146D-03  -0.11033D-03   0.17645D-03   0.96216D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)         9    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Right Boom (Sensor Assembly)         9    -0.21155D-01   0.25184D-03  -0.53147D-02  -0.21596D-04  -0.16382D-04   0.68570D-03
Bottom Payload Boom (Left) Ant      24     0.25588D-01  -0.36947D-01  -0.34539D-02   0.99325D-04   0.28087D-03   0.39292D-04
Bottom Payload Boom (Left) Ant      24     0.25588D-01  -0.36947D-01  -0.34539D-02   0.99325D-04   0.28087D-03   0.39292D-04
Bottom Payload Boom (Left) Ant      24     0.25588D-01  -0.36947D-01  -0.34539D-02   0.99325D-04   0.28087D-03   0.39292D-04
Right SA Boom, Outboard the Hi       7    -0.53756D-01   0.28209D-03  -0.58951D-02   0.49782D-04  -0.20819D-03  -0.27925D-03
Left SA Boom, Outboard the Hin      16    -0.50234D-01   0.80336D-03  -0.66373D-02  -0.11988D-04   0.21548D-03   0.24107D-03

MODE# 29/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.7113       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.69217D-03  -0.21677D-01  -0.46064D-03  -0.10020D-03  -0.40916D-04   0.73097D-04
Top Right RCS Thruster Assembl      25    -0.69217D-03  -0.21677D-01  -0.46064D-03  -0.10020D-03  -0.40916D-04   0.73097D-04
Top Left RCS Thrusters Assembl      26     0.22853D-02  -0.21465D-01  -0.17503D-02  -0.11064D-03  -0.55212D-04  -0.30785D-04
Top Left RCS Thrusters Assembl      26     0.22853D-02  -0.21465D-01  -0.17503D-02  -0.11064D-03  -0.55212D-04  -0.30785D-04
Bottom Right RCS Thruster Asse      27     0.42646D-02  -0.85364D-02   0.10306D-03   0.63965D-04   0.10612D-03   0.62742D-04
Bottom Right RCS Thruster Asse      27     0.42646D-02  -0.85364D-02   0.10306D-03   0.63965D-04   0.10612D-03   0.62742D-04
Bottom Left RCS Thrusters Asse      28     0.51422D-02  -0.87098D-02  -0.23245D-02   0.55493D-04   0.10770D-03  -0.54696D-04
Bottom Left RCS Thrusters Asse      28     0.51422D-02  -0.87098D-02  -0.23245D-02   0.55493D-04   0.10770D-03  -0.54696D-04
Center Habitat Module               21     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module               21     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04
Center Habitat Module               21     0.10150D-02   0.58688D-03  -0.36356D-02   0.23123D-04   0.37522D-04   0.29848D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.51490D-02   0.94482D-03  -0.42733D-04  -0.23534D-04  -0.18934D-04   0.23184D-03
Right Keel/Boom Intrsect, CMG       10    -0.51490D-02   0.94482D-03  -0.42733D-04  -0.23534D-04  -0.18934D-04   0.23184D-03
Right Keel/Boom Intrsect, CMG       10    -0.51490D-02   0.94482D-03  -0.42733D-04  -0.23534D-04  -0.18934D-04   0.23184D-03
Payload boom, (top-right)            1     0.80878D-06  -0.23125D-01  -0.50726D-03  -0.60079D-04  -0.41803D-04   0.55142D-04
Payload boom, (top-right)            1     0.80878D-06  -0.23125D-01  -0.50726D-03  -0.60079D-04  -0.41803D-04   0.55142D-04
Payload boom, (top-right)            1     0.80878D-06  -0.23125D-01  -0.50726D-03  -0.60079D-04  -0.41803D-04   0.55142D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)         9    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)         9    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Solar Array Boom               5     0.21090D-01   0.11246D-02   0.46533D-02   0.34148D-04  -0.96526D-03  -0.49556D-03
Right Solar Array Boom               5     0.21090D-01   0.11246D-02   0.46533D-02   0.34148D-04  -0.96526D-03  -0.49556D-03
Left SA Boom, Extreeme End          18     0.19900D-01   0.11410D-02  -0.27416D-02  -0.46513D-04   0.86452D-03   0.47719D-03
Left SA Boom, Extreeme End          18     0.19900D-01   0.11410D-02  -0.27416D-02  -0.46513D-04   0.86452D-03   0.47719D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)         9    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Right Boom (Sensor Assembly)         9    -0.98315D-02   0.95024D-03  -0.17819D-03  -0.80723D-05  -0.21222D-04   0.25262D-03
Bottom Payload Boom (Left) Ant      24     0.69649D-02  -0.95600D-02  -0.23429D-02   0.41413D-04   0.10857D-03  -0.33277D-04
Bottom Payload Boom (Left) Ant      24     0.69649D-02  -0.95600D-02  -0.23429D-02   0.41413D-04   0.10857D-03  -0.33277D-04
Bottom Payload Boom (Left) Ant      24     0.69649D-02  -0.95600D-02  -0.23429D-02   0.41413D-04   0.10857D-03  -0.33277D-04
Right SA Boom, Outboard the Hi       7    -0.20642D-01   0.10149D-02   0.60561D-03   0.35879D-04  -0.12043D-03  -0.17687D-03
Left SA Boom, Outboard the Hin      16    -0.20160D-01   0.11936D-02  -0.51542D-02   0.12581D-04   0.11978D-03   0.16440D-03

MODE# 30/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.8636       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.67316D-02  -0.51642D-01   0.20506D-01  -0.40685D-03  -0.97960D-05  -0.15696D-03
Top Right RCS Thruster Assembl      25     0.67316D-02  -0.51642D-01   0.20506D-01  -0.40685D-03  -0.97960D-05  -0.15696D-03
Top Left RCS Thrusters Assembl      26    -0.13585D-01  -0.57622D-01   0.12198D-01  -0.11413D-03   0.12355D-03  -0.15253D-03
Top Left RCS Thrusters Assembl      26    -0.13585D-01  -0.57622D-01   0.12198D-01  -0.11413D-03   0.12355D-03  -0.15253D-03
Bottom Right RCS Thruster Asse      27     0.14106D-01  -0.28345D-01   0.22147D-01   0.77478D-04   0.11670D-03  -0.18385D-03
Bottom Right RCS Thruster Asse      27     0.14106D-01  -0.28345D-01   0.22147D-01   0.77478D-04   0.11670D-03  -0.18385D-03
Bottom Left RCS Thrusters Asse      28    -0.92732D-02  -0.22786D-01   0.10622D-01   0.34499D-03  -0.41981D-04  -0.16955D-03
Bottom Left RCS Thrusters Asse      28    -0.92732D-02  -0.22786D-01   0.10622D-01   0.34499D-03  -0.41981D-04  -0.16955D-03
Center Habitat Module               21    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module               21    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04
Center Habitat Module               21    -0.18153D-02   0.44779D-03  -0.97703D-02   0.32842D-03   0.31870D-03   0.64598D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.15887D-02   0.61989D-02   0.21124D-01   0.37013D-03  -0.41712D-04  -0.67442D-04
Right Keel/Boom Intrsect, CMG       10     0.15887D-02   0.61989D-02   0.21124D-01   0.37013D-03  -0.41712D-04  -0.67442D-04
Right Keel/Boom Intrsect, CMG       10     0.15887D-02   0.61989D-02   0.21124D-01   0.37013D-03  -0.41712D-04  -0.67442D-04
Payload boom, (top-right)            1     0.68217D-02  -0.58070D-01   0.20401D-01  -0.27527D-03  -0.37457D-05  -0.16777D-03
Payload boom, (top-right)            1     0.68217D-02  -0.58070D-01   0.20401D-01  -0.27527D-03  -0.37457D-05  -0.16777D-03
Payload boom, (top-right)            1     0.68217D-02  -0.58070D-01   0.20401D-01  -0.27527D-03  -0.37457D-05  -0.16777D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)         9     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)         9     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Solar Array Boom               5    -0.11780D-01   0.78112D-02  -0.19425D-01  -0.11866D-02   0.69452D-03   0.16174D-03
Right Solar Array Boom               5    -0.11780D-01   0.78112D-02  -0.19425D-01  -0.11866D-02   0.69452D-03   0.16174D-03
Left SA Boom, Extreeme End          18     0.81602D-02   0.56711D-02  -0.18170D-01   0.10530D-02   0.54814D-03   0.78108D-04
Left SA Boom, Extreeme End          18     0.81602D-02   0.56711D-02  -0.18170D-01   0.10530D-02   0.54814D-03   0.78108D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)         9     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Right Boom (Sensor Assembly)         9     0.27935D-02   0.64058D-02   0.30566D-01   0.52798D-03  -0.18637D-03  -0.66738D-04
Bottom Payload Boom (Left) Ant      24    -0.98941D-02  -0.28609D-01   0.10593D-01   0.28741D-03  -0.35051D-04  -0.18611D-03
Bottom Payload Boom (Left) Ant      24    -0.98941D-02  -0.28609D-01   0.10593D-01   0.28741D-03  -0.35051D-04  -0.18611D-03
Bottom Payload Boom (Left) Ant      24    -0.98941D-02  -0.28609D-01   0.10593D-01   0.28741D-03  -0.35051D-04  -0.18611D-03
Right SA Boom, Outboard the Hi       7     0.44727D-02   0.70287D-02   0.64375D-01  -0.19614D-03  -0.31382D-04   0.95531D-04
Left SA Boom, Outboard the Hin      16    -0.82402D-03   0.50154D-02   0.55524D-01   0.14644D-03  -0.24367D-04   0.65365D-04

MODE# 31/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.9866       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.84824D-02  -0.10133D+00   0.10125D-02  -0.39854D-03  -0.12155D-03  -0.91410D-04
Top Right RCS Thruster Assembl      25     0.84824D-02  -0.10133D+00   0.10125D-02  -0.39854D-03  -0.12155D-03  -0.91410D-04
Top Left RCS Thrusters Assembl      26     0.17181D-02  -0.98201D-01  -0.16214D-01  -0.54990D-03  -0.37841D-04  -0.51754D-04
Top Left RCS Thrusters Assembl      26     0.17181D-02  -0.98201D-01  -0.16214D-01  -0.54990D-03  -0.37841D-04  -0.51754D-04
Bottom Right RCS Thruster Asse      27     0.83208D-02  -0.37563D-01   0.38653D-02   0.43039D-03   0.56903D-04  -0.23350D-03
Bottom Right RCS Thruster Asse      27     0.83208D-02  -0.37563D-01   0.38653D-02   0.43039D-03   0.56903D-04  -0.23350D-03
Bottom Left RCS Thrusters Asse      28    -0.15025D-01  -0.40611D-01  -0.19120D-01   0.28162D-03  -0.14576D-03  -0.15038D-03
Bottom Left RCS Thrusters Asse      28    -0.15025D-01  -0.40611D-01  -0.19120D-01   0.28162D-03  -0.14576D-03  -0.15038D-03
Center Habitat Module               21    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module               21    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03
Center Habitat Module               21    -0.30320D-02   0.84723D-03   0.20510D-01   0.54499D-03  -0.20861D-03   0.20344D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.24720D-02   0.10916D-01   0.31714D-02  -0.29072D-03   0.46370D-04  -0.26743D-03
Right Keel/Boom Intrsect, CMG       10    -0.24720D-02   0.10916D-01   0.31714D-02  -0.29072D-03   0.46370D-04  -0.26743D-03
Right Keel/Boom Intrsect, CMG       10    -0.24720D-02   0.10916D-01   0.31714D-02  -0.29072D-03   0.46370D-04  -0.26743D-03
Payload boom, (top-right)            1     0.10528D-01  -0.10670D+00   0.76694D-03  -0.19378D-03  -0.11934D-03  -0.73813D-04
Payload boom, (top-right)            1     0.10528D-01  -0.10670D+00   0.76694D-03  -0.19378D-03  -0.11934D-03  -0.73813D-04
Payload boom, (top-right)            1     0.10528D-01  -0.10670D+00   0.76694D-03  -0.19378D-03  -0.11934D-03  -0.73813D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)         9     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)         9     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Solar Array Boom               5    -0.12274D-01   0.11975D-01   0.71338D-02   0.35040D-03   0.87886D-04   0.42857D-03
Right Solar Array Boom               5    -0.12274D-01   0.11975D-01   0.71338D-02   0.35040D-03   0.87886D-04   0.42857D-03
Left SA Boom, Extreeme End          18    -0.17381D-02   0.12642D-01   0.13000D-01  -0.73720D-03  -0.31340D-03   0.30462D-04
Left SA Boom, Extreeme End          18    -0.17381D-02   0.12642D-01   0.13000D-01  -0.73720D-03  -0.31340D-03   0.30462D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)         9     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Right Boom (Sensor Assembly)         9     0.32395D-02   0.11159D-01  -0.24188D-02  -0.31732D-03   0.68884D-04  -0.34027D-03
Bottom Payload Boom (Left) Ant      24    -0.17421D-01  -0.44908D-01  -0.19211D-01   0.22734D-03  -0.13842D-03  -0.17010D-03
Bottom Payload Boom (Left) Ant      24    -0.17421D-01  -0.44908D-01  -0.19211D-01   0.22734D-03  -0.13842D-03  -0.17010D-03
Bottom Payload Boom (Left) Ant      24    -0.17421D-01  -0.44908D-01  -0.19211D-01   0.22734D-03  -0.13842D-03  -0.17010D-03
Right SA Boom, Outboard the Hi       7     0.21590D-01   0.11704D-01  -0.18777D-01   0.38682D-04   0.98790D-04   0.72572D-04
Left SA Boom, Outboard the Hin      16    -0.35198D-02   0.12440D-01  -0.42306D-01  -0.15575D-03   0.61961D-04  -0.18757D-04

MODE# 32/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.3161       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.14036D-01   0.62271D-01  -0.11702D-01   0.23663D-03   0.87949D-04   0.15396D-03
Top Right RCS Thruster Assembl      25    -0.14036D-01   0.62271D-01  -0.11702D-01   0.23663D-03   0.87949D-04   0.15396D-03
Top Left RCS Thrusters Assembl      26     0.11581D-01   0.62056D-01   0.13501D-01   0.24460D-03  -0.39150D-04   0.16997D-03
Top Left RCS Thrusters Assembl      26     0.11581D-01   0.62056D-01   0.13501D-01   0.24460D-03  -0.39150D-04   0.16997D-03
Bottom Right RCS Thruster Asse      27    -0.15924D-01  -0.16282D-01  -0.12710D-01  -0.63396D-04  -0.10387D-03   0.22187D-03
Bottom Right RCS Thruster Asse      27    -0.15924D-01  -0.16282D-01  -0.12710D-01  -0.63396D-04  -0.10387D-03   0.22187D-03
Bottom Left RCS Thrusters Asse      28     0.15865D-01  -0.15817D-01   0.14548D-01  -0.38202D-04   0.76519D-04   0.19412D-03
Bottom Left RCS Thrusters Asse      28     0.15865D-01  -0.15817D-01   0.14548D-01  -0.38202D-04   0.76519D-04   0.19412D-03
Center Habitat Module               21    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module               21    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03
Center Habitat Module               21    -0.22038D-02  -0.41660D-02  -0.61765D-02  -0.16463D-03   0.66326D-04   0.10738D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.20633D-02  -0.53440D-02  -0.12970D-01   0.27254D-04   0.72259D-05  -0.91795D-04
Right Keel/Boom Intrsect, CMG       10    -0.20633D-02  -0.53440D-02  -0.12970D-01   0.27254D-04   0.72259D-05  -0.91795D-04
Right Keel/Boom Intrsect, CMG       10    -0.20633D-02  -0.53440D-02  -0.12970D-01   0.27254D-04   0.72259D-05  -0.91795D-04
Payload boom, (top-right)            1    -0.15426D-01   0.65390D-01  -0.11538D-01   0.84048D-04   0.82421D-04   0.18485D-03
Payload boom, (top-right)            1    -0.15426D-01   0.65390D-01  -0.11538D-01   0.84048D-04   0.82421D-04   0.18485D-03
Payload boom, (top-right)            1    -0.15426D-01   0.65390D-01  -0.11538D-01   0.84048D-04   0.82421D-04   0.18485D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)         9     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)         9     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Solar Array Boom               5    -0.45080D-02  -0.63782D-02   0.45290D-02   0.47282D-03  -0.45352D-04   0.23622D-03
Right Solar Array Boom               5    -0.45080D-02  -0.63782D-02   0.45290D-02   0.47282D-03  -0.45352D-04   0.23622D-03
Left SA Boom, Extreeme End          18     0.10462D-01  -0.47219D-02  -0.85103D-02   0.55819D-03   0.27481D-03   0.30577D-03
Left SA Boom, Extreeme End          18     0.10462D-01  -0.47219D-02  -0.85103D-02   0.55819D-03   0.27481D-03   0.30577D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)         9     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Right Boom (Sensor Assembly)         9     0.54862D-03  -0.54087D-02  -0.14753D-01  -0.92321D-04   0.58489D-04  -0.16826D-03
Bottom Payload Boom (Left) Ant      24     0.17039D-01  -0.14873D-01   0.14497D-01  -0.95626D-04   0.68574D-04   0.23280D-03
Bottom Payload Boom (Left) Ant      24     0.17039D-01  -0.14873D-01   0.14497D-01  -0.95626D-04   0.68574D-04   0.23280D-03
Bottom Payload Boom (Left) Ant      24     0.17039D-01  -0.14873D-01   0.14497D-01  -0.95626D-04   0.68574D-04   0.23280D-03
Right SA Boom, Outboard the Hi       7     0.11876D-01  -0.58049D-02  -0.26195D-01   0.52823D-04   0.72888D-04   0.82654D-05
Left SA Boom, Outboard the Hin      16    -0.13062D-01  -0.47122D-02   0.31589D-01   0.97218D-04   0.35938D-04   0.38731D-04

MODE# 33/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4006       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.15083D-01  -0.16294D-01   0.21193D-02  -0.66984D-04  -0.50917D-04  -0.25879D-03
Top Right RCS Thruster Assembl      25     0.15083D-01  -0.16294D-01   0.21193D-02  -0.66984D-04  -0.50917D-04  -0.25879D-03
Top Left RCS Thrusters Assembl      26    -0.15497D-01  -0.15993D-01  -0.28992D-02  -0.82460D-04   0.16090D-03  -0.18343D-03
Top Left RCS Thrusters Assembl      26    -0.15497D-01  -0.15993D-01  -0.28992D-02  -0.82460D-04   0.16090D-03  -0.18343D-03
Bottom Right RCS Thruster Asse      27     0.10741D-01  -0.20793D-02   0.25451D-02   0.46918D-04  -0.12478D-04  -0.29249D-03
Bottom Right RCS Thruster Asse      27     0.10741D-01  -0.20793D-02   0.25451D-02   0.46918D-04  -0.12478D-04  -0.29249D-03
Bottom Left RCS Thrusters Asse      28    -0.20467D-01  -0.20592D-02  -0.33280D-02   0.48658D-04  -0.23837D-03  -0.15541D-03
Bottom Left RCS Thrusters Asse      28    -0.20467D-01  -0.20592D-02  -0.33280D-02   0.48658D-04  -0.23837D-03  -0.15541D-03
Center Habitat Module               21    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module               21    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05
Center Habitat Module               21    -0.19738D-02   0.92837D-03   0.64257D-02   0.10513D-03  -0.68021D-04   0.78308D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.66667D-02   0.19865D-02   0.24711D-02  -0.14086D-04   0.17128D-04  -0.21772D-03
Right Keel/Boom Intrsect, CMG       10     0.66667D-02   0.19865D-02   0.24711D-02  -0.14086D-04   0.17128D-04  -0.21772D-03
Right Keel/Boom Intrsect, CMG       10     0.66667D-02   0.19865D-02   0.24711D-02  -0.14086D-04   0.17128D-04  -0.21772D-03
Payload boom, (top-right)            1     0.15836D-01  -0.17195D-01   0.20754D-02  -0.28219D-04  -0.41801D-04  -0.26648D-03
Payload boom, (top-right)            1     0.15836D-01  -0.17195D-01   0.20754D-02  -0.28219D-04  -0.41801D-04  -0.26648D-03
Payload boom, (top-right)            1     0.15836D-01  -0.17195D-01   0.20754D-02  -0.28219D-04  -0.41801D-04  -0.26648D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)         9     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)         9     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Solar Array Boom               5    -0.70207D-02   0.17813D-02  -0.98349D-03  -0.64148D-04   0.95096D-04   0.31196D-03
Right Solar Array Boom               5    -0.70207D-02   0.17813D-02  -0.98349D-03  -0.64148D-04   0.95096D-04   0.31196D-03
Left SA Boom, Extreeme End          18    -0.90049D-02   0.41789D-02   0.25185D-02  -0.98514D-04  -0.15173D-03  -0.38045D-03
Left SA Boom, Extreeme End          18    -0.90049D-02   0.41789D-02   0.25185D-02  -0.98514D-04  -0.15173D-03  -0.38045D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)         9     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Right Boom (Sensor Assembly)         9     0.10908D-01   0.18305D-02   0.25250D-02   0.17488D-05   0.13132D-04  -0.17627D-03
Bottom Payload Boom (Left) Ant      24    -0.24389D-01  -0.28715D-02  -0.33318D-02   0.47410D-04  -0.23029D-03  -0.20159D-03
Bottom Payload Boom (Left) Ant      24    -0.24389D-01  -0.28715D-02  -0.33318D-02   0.47410D-04  -0.23029D-03  -0.20159D-03
Bottom Payload Boom (Left) Ant      24    -0.24389D-01  -0.28715D-02  -0.33318D-02   0.47410D-04  -0.23029D-03  -0.20159D-03
Right SA Boom, Outboard the Hi       7     0.18031D-01   0.17279D-02   0.35205D-02  -0.13262D-04   0.51701D-04   0.84680D-04
Left SA Boom, Outboard the Hin      16     0.20566D-01   0.39503D-02  -0.59308D-02  -0.32105D-04  -0.53506D-04  -0.83875D-04

MODE# 34/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.4561       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Right RCS Thruster Assembl      25     0.68877D-01   0.32451D-01  -0.13368D-01   0.81686D-04  -0.54215D-03  -0.89950D-03
Top Left RCS Thrusters Assembl      26    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Top Left RCS Thrusters Assembl      26    -0.61060D-01   0.33163D-01   0.10821D-01   0.44784D-04   0.43273D-03  -0.10258D-02
Bottom Right RCS Thruster Asse      27     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Right RCS Thruster Asse      27     0.52990D-01  -0.41696D-01  -0.13083D-01   0.15785D-03   0.43738D-03  -0.84575D-03
Bottom Left RCS Thrusters Asse      28    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03
Bottom Left RCS Thrusters Asse      28    -0.55653D-01  -0.42188D-01   0.10568D-01   0.13646D-03  -0.41677D-03  -0.78052D-03
Center Habitat Module               21    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module               21    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03
Center Habitat Module               21    -0.55445D-02  -0.12006D-02   0.16661D-03   0.17862D-03   0.68340D-04   0.36391D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04
Right Keel/Boom Intrsect, CMG       10    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04
Right Keel/Boom Intrsect, CMG       10    -0.32730D-02   0.32260D-02  -0.13922D-01  -0.82219D-04  -0.36901D-04  -0.96619D-04
Payload boom, (top-right)            1     0.77542D-01   0.33373D-01  -0.13280D-01  -0.81646D-05  -0.50268D-03  -0.10058D-02
Payload boom, (top-right)            1     0.77542D-01   0.33373D-01  -0.13280D-01  -0.81646D-05  -0.50268D-03  -0.10058D-02
Payload boom, (top-right)            1     0.77542D-01   0.33373D-01  -0.13280D-01  -0.81646D-05  -0.50268D-03  -0.10058D-02

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)         9    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)         9    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Solar Array Boom               5     0.16018D-02   0.28662D-02   0.95619D-02   0.73241D-03  -0.14322D-03  -0.21583D-05
Right Solar Array Boom               5     0.16018D-02   0.28662D-02   0.95619D-02   0.73241D-03  -0.14322D-03  -0.21583D-05
Left SA Boom, Extreeme End          18     0.59330D-02   0.44159D-02  -0.59648D-02   0.50941D-03   0.16004D-03   0.17708D-03
Left SA Boom, Extreeme End          18     0.59330D-02   0.44159D-02  -0.59648D-02   0.50941D-03   0.16004D-03   0.17708D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)         9    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Right Boom (Sensor Assembly)         9    -0.19587D-02   0.31762D-02  -0.18543D-01  -0.25141D-03   0.30760D-04  -0.65497D-04
Bottom Payload Boom (Left) Ant      24    -0.62287D-01  -0.43837D-01   0.10444D-01   0.22066D-04  -0.38212D-03  -0.86082D-03
Bottom Payload Boom (Left) Ant      24    -0.62287D-01  -0.43837D-01   0.10444D-01   0.22066D-04  -0.38212D-03  -0.86082D-03
Bottom Payload Boom (Left) Ant      24    -0.62287D-01  -0.43837D-01   0.10444D-01   0.22066D-04  -0.38212D-03  -0.86082D-03
Right SA Boom, Outboard the Hi       7     0.21769D-03   0.30984D-02  -0.40367D-01   0.83584D-04   0.15386D-04  -0.23561D-04
Left SA Boom, Outboard the Hin      16    -0.91097D-02   0.39789D-02   0.27533D-01   0.52429D-04   0.18443D-04   0.49813D-04

MODE# 35/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.8273       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Right RCS Thruster Assembl      25    -0.12814D+00   0.78650D-03  -0.12264D-02  -0.17513D-04   0.98904D-03   0.16534D-02
Top Left RCS Thrusters Assembl      26     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Top Left RCS Thrusters Assembl      26     0.11957D+00   0.86476D-03   0.16759D-02  -0.21781D-04  -0.93347D-03   0.18810D-02
Bottom Right RCS Thruster Asse      27    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Right RCS Thruster Asse      27    -0.10639D+00  -0.15568D-01  -0.80298D-03   0.10075D-03  -0.86695D-03   0.16608D-02
Bottom Left RCS Thrusters Asse      28     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02
Bottom Left RCS Thrusters Asse      28     0.11303D+00  -0.15560D-01   0.12708D-02   0.10162D-03   0.91076D-03   0.14761D-02
Center Habitat Module               21    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module               21    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04
Center Habitat Module               21    -0.40868D-03   0.33331D-02   0.31115D-02   0.21792D-03   0.91069D-05   0.32419D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03
Right Keel/Boom Intrsect, CMG       10     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03
Right Keel/Boom Intrsect, CMG       10     0.74582D-02   0.39460D-02  -0.12074D-02  -0.42245D-04   0.78947D-04  -0.25132D-03
Payload boom, (top-right)            1    -0.14382D+00   0.49853D-03  -0.12261D-02  -0.18722D-04   0.90959D-03   0.19008D-02
Payload boom, (top-right)            1    -0.14382D+00   0.49853D-03  -0.12261D-02  -0.18722D-04   0.90959D-03   0.19008D-02
Payload boom, (top-right)            1    -0.14382D+00   0.49853D-03  -0.12261D-02  -0.18722D-04   0.90959D-03   0.19008D-02

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)         9     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)         9     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Solar Array Boom               5    -0.17123D-01   0.38936D-02   0.20893D-02   0.22708D-03   0.11005D-03   0.81992D-03
Right Solar Array Boom               5    -0.17123D-01   0.38936D-02   0.20893D-02   0.22708D-03   0.11005D-03   0.81992D-03
Left SA Boom, Extreeme End          18     0.16946D-01   0.47593D-02  -0.31958D-02   0.22745D-03   0.19367D-03   0.74806D-03
Left SA Boom, Extreeme End          18     0.16946D-01   0.47593D-02  -0.31958D-02   0.22745D-03   0.19367D-03   0.74806D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)         9     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Right Boom (Sensor Assembly)         9     0.15498D-01   0.39504D-02  -0.31054D-02  -0.10494D-03   0.93482D-04  -0.42032D-03
Bottom Payload Boom (Left) Ant      24     0.12750D+00  -0.17061D-01   0.12256D-02   0.60655D-04   0.83788D-03   0.16950D-02
Bottom Payload Boom (Left) Ant      24     0.12750D+00  -0.17061D-01   0.12256D-02   0.60655D-04   0.83788D-03   0.16950D-02
Bottom Payload Boom (Left) Ant      24     0.12750D+00  -0.17061D-01   0.12256D-02   0.60655D-04   0.83788D-03   0.16950D-02
Right SA Boom, Outboard the Hi       7     0.44329D-01   0.40012D-02  -0.11918D-01  -0.87074D-06   0.17604D-03   0.10957D-03
Left SA Boom, Outboard the Hin      16    -0.40107D-01   0.45444D-02   0.11102D-01   0.81708D-05   0.13758D-03   0.11423D-03

MODE# 36/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    7.5067       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Right RCS Thruster Assembl      25    -0.78909D-02  -0.10833D-02   0.48861D-02   0.51263D-04   0.15452D-03   0.14248D-03
Top Left RCS Thrusters Assembl      26     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Top Left RCS Thrusters Assembl      26     0.43312D-02  -0.86883D-03  -0.12020D-01   0.40624D-04  -0.86993D-04   0.15229D-03
Bottom Right RCS Thruster Asse      27    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Right RCS Thruster Asse      27    -0.91481D-02  -0.28858D-01   0.59380D-02   0.33191D-03  -0.14222D-03   0.23425D-03
Bottom Left RCS Thrusters Asse      28     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03
Bottom Left RCS Thrusters Asse      28     0.11997D-01  -0.28758D-01  -0.13004D-01   0.33530D-03   0.18485D-03   0.19459D-03
Center Habitat Module               21     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module               21     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03
Center Habitat Module               21     0.15576D-01   0.12275D-01   0.20339D-01   0.88956D-03  -0.40854D-03  -0.89371D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03
Right Keel/Boom Intrsect, CMG       10     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03
Right Keel/Boom Intrsect, CMG       10     0.90868D-02   0.11222D-01   0.50654D-02  -0.21637D-03  -0.10534D-04   0.30383D-03
Payload boom, (top-right)            1    -0.10457D-01   0.18317D-04   0.48541D-02   0.82010D-04   0.14618D-03   0.12671D-03
Payload boom, (top-right)            1    -0.10457D-01   0.18317D-04   0.48541D-02   0.82010D-04   0.14618D-03   0.12671D-03
Payload boom, (top-right)            1    -0.10457D-01   0.18317D-04   0.48541D-02   0.82010D-04   0.14618D-03   0.12671D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)         9     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)         9     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Solar Array Boom               5     0.10825D-01   0.12631D-01   0.10387D-01   0.81186D-03  -0.51268D-04  -0.55225D-03
Right Solar Array Boom               5     0.10825D-01   0.12631D-01   0.10387D-01   0.81186D-03  -0.51268D-04  -0.55225D-03
Left SA Boom, Extreeme End          18    -0.94460D-02   0.17142D-01  -0.68973D-02   0.97794D-03  -0.47066D-05  -0.60900D-03
Left SA Boom, Extreeme End          18    -0.94460D-02   0.17142D-01  -0.68973D-02   0.97794D-03  -0.47066D-05  -0.60900D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)         9     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Right Boom (Sensor Assembly)         9     0.14625D-02   0.11464D-01  -0.29960D-02  -0.45949D-03  -0.29051D-04   0.43217D-03
Bottom Payload Boom (Left) Ant      24     0.15044D-01  -0.34147D-01  -0.13096D-01   0.26846D-03   0.17309D-03   0.19145D-03
Bottom Payload Boom (Left) Ant      24     0.15044D-01  -0.34147D-01  -0.13096D-01   0.26846D-03   0.17309D-03   0.19145D-03
Bottom Payload Boom (Left) Ant      24     0.15044D-01  -0.34147D-01  -0.13096D-01   0.26846D-03   0.17309D-03   0.19145D-03
Right SA Boom, Outboard the Hi       7    -0.26886D-01   0.12202D-01  -0.40352D-01  -0.39838D-04  -0.19421D-03   0.15964D-04
Left SA Boom, Outboard the Hin      16     0.28460D-01   0.15171D-01   0.40519D-01  -0.16913D-03  -0.10330D-03   0.44394D-04

MODE# 37/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.6158       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Right RCS Thruster Assembl      25     0.13846D-01   0.28156D-02  -0.22409D-02   0.90322D-04  -0.13997D-03  -0.29812D-03
Top Left RCS Thrusters Assembl      26    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Top Left RCS Thrusters Assembl      26    -0.21484D-01   0.15306D-02  -0.20147D-01   0.14988D-03   0.32215D-03  -0.30638D-03
Bottom Right RCS Thruster Asse      27     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Right RCS Thruster Asse      27     0.21653D-02   0.20129D-02  -0.24951D-02   0.14212D-04   0.18616D-03   0.37213D-04
Bottom Left RCS Thrusters Asse      28     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05
Bottom Left RCS Thrusters Asse      28     0.89212D-02   0.35463D-02  -0.19944D-01   0.82591D-04   0.15697D-03  -0.56216D-05
Center Habitat Module               21    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module               21    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03
Center Habitat Module               21    -0.45119D-02  -0.10802D-01   0.18717D-01  -0.52082D-03  -0.13537D-03   0.37602D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03
Right Keel/Boom Intrsect, CMG       10    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03
Right Keel/Boom Intrsect, CMG       10    -0.10149D-01  -0.41095D-02  -0.19512D-02   0.44093D-04  -0.83161D-04  -0.15432D-03
Payload boom, (top-right)            1     0.16000D-01   0.43494D-02  -0.22642D-02   0.10629D-03  -0.12064D-03  -0.31834D-03
Payload boom, (top-right)            1     0.16000D-01   0.43494D-02  -0.22642D-02   0.10629D-03  -0.12064D-03  -0.31834D-03
Payload boom, (top-right)            1     0.16000D-01   0.43494D-02  -0.22642D-02   0.10629D-03  -0.12064D-03  -0.31834D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)         9    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)         9    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Solar Array Boom               5    -0.72630D-02  -0.53016D-02  -0.25077D-02  -0.83915D-04   0.20946D-03   0.33377D-03
Right Solar Array Boom               5    -0.72630D-02  -0.53016D-02  -0.25077D-02  -0.83915D-04   0.20946D-03   0.33377D-03
Left SA Boom, Extreeme End          18     0.36650D-02  -0.20268D-02  -0.65125D-02   0.74954D-03   0.96048D-04   0.12608D-03
Left SA Boom, Extreeme End          18     0.36650D-02  -0.20268D-02  -0.65125D-02   0.74954D-03   0.96048D-04   0.12608D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)         9    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Right Boom (Sensor Assembly)         9    -0.58943D-02  -0.42673D-02  -0.66530D-03   0.73555D-04  -0.77761D-04  -0.25416D-03
Bottom Payload Boom (Left) Ant      24     0.11649D-01   0.18858D-02  -0.19951D-01   0.10202D-03   0.16056D-03   0.10617D-04
Bottom Payload Boom (Left) Ant      24     0.11649D-01   0.18858D-02  -0.19951D-01   0.10202D-03   0.16056D-03   0.10617D-04
Bottom Payload Boom (Left) Ant      24     0.11649D-01   0.18858D-02  -0.19951D-01   0.10202D-03   0.16056D-03   0.10617D-04
Right SA Boom, Outboard the Hi       7     0.12905D-01  -0.47938D-02   0.45706D-02  -0.53009D-05  -0.81997D-04  -0.53405D-04
Left SA Boom, Outboard the Hin      16    -0.54271D-02  -0.24793D-02   0.27782D-01  -0.20383D-03  -0.22476D-04  -0.12598D-04

MODE# 38/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.2010       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Right RCS Thruster Assembl      25     0.13182D-01  -0.47412D-02   0.27232D-01   0.21427D-03  -0.24958D-03  -0.17674D-03
Top Left RCS Thrusters Assembl      26    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Top Left RCS Thrusters Assembl      26    -0.85240D-02  -0.46261D-02  -0.25823D-01   0.21689D-03   0.17929D-03  -0.24190D-03
Bottom Right RCS Thruster Asse      27     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Right RCS Thruster Asse      27     0.13797D-01   0.19725D-02   0.27552D-01   0.26444D-03   0.17654D-03  -0.34885D-03
Bottom Left RCS Thrusters Asse      28    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03
Bottom Left RCS Thrusters Asse      28    -0.21012D-01   0.16973D-02  -0.25977D-01   0.24371D-03  -0.41758D-03  -0.27242D-03
Center Habitat Module               21    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module               21    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03
Center Habitat Module               21    -0.29781D-02  -0.20399D-01   0.39108D-02   0.66456D-03  -0.50550D-03   0.27719D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.13367D-01   0.10809D-02   0.26664D-01  -0.20114D-03   0.46546D-04  -0.12775D-03
Right Keel/Boom Intrsect, CMG       10    -0.13367D-01   0.10809D-02   0.26664D-01  -0.20114D-03   0.46546D-04  -0.12775D-03
Right Keel/Boom Intrsect, CMG       10    -0.13367D-01   0.10809D-02   0.26664D-01  -0.20114D-03   0.46546D-04  -0.12775D-03
Payload boom, (top-right)            1     0.17296D-01  -0.63837D-03   0.27194D-01   0.28202D-03  -0.23418D-03  -0.18874D-03
Payload boom, (top-right)            1     0.17296D-01  -0.63837D-03   0.27194D-01   0.28202D-03  -0.23418D-03  -0.18874D-03
Payload boom, (top-right)            1     0.17296D-01  -0.63837D-03   0.27194D-01   0.28202D-03  -0.23418D-03  -0.18874D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)         9    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)         9    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Solar Array Boom               5    -0.46806D-02  -0.43565D-03   0.46398D-02   0.76774D-03   0.56389D-04   0.30488D-03
Right Solar Array Boom               5    -0.46806D-02  -0.43565D-03   0.46398D-02   0.76774D-03   0.56389D-04   0.30488D-03
Left SA Boom, Extreeme End          18     0.13990D-01   0.47949D-02  -0.65422D-02   0.84304D-03   0.34249D-03   0.59869D-03
Left SA Boom, Extreeme End          18     0.13990D-01   0.47949D-02  -0.65422D-02   0.84304D-03   0.34249D-03   0.59869D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)         9    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Right Boom (Sensor Assembly)         9    -0.96082D-02   0.97651D-03   0.19234D-01  -0.46610D-03   0.36107D-04  -0.24137D-03
Bottom Payload Boom (Left) Ant      24    -0.27944D-01  -0.28282D-02  -0.25952D-01   0.30125D-03  -0.39710D-03  -0.29230D-03
Bottom Payload Boom (Left) Ant      24    -0.27944D-01  -0.28282D-02  -0.25952D-01   0.30125D-03  -0.39710D-03  -0.29230D-03
Bottom Payload Boom (Left) Ant      24    -0.27944D-01  -0.28282D-02  -0.25952D-01   0.30125D-03  -0.39710D-03  -0.29230D-03
Right SA Boom, Outboard the Hi       7     0.10178D-01   0.52389D-03  -0.23064D-01  -0.29870D-03  -0.81196D-05  -0.10847D-03
Left SA Boom, Outboard the Hin      16    -0.23116D-01   0.37040D-02   0.25245D-01  -0.29572D-03  -0.45629D-04  -0.13070D-03
------------------------------------------------------------------------------------------------------------------------
Definition of System Variables                                                                      
                                                                                                    
Inputs  =  17                                                                                       
  1    Fx  RCS No  1 Applied at Node # 25 (lbf)                                                      
  2   -Fy  RCS No  2 Applied at Node # 25 (lbf)                                                      
  3    Fx  RCS No  3 Applied at Node # 26 (lbf)                                                      
  4    Fy  RCS No  4 Applied at Node # 26 (lbf)                                                      
  5    Fx  RCS No  5 Applied at Node # 27 (lbf)                                                      
  6   -Fy  RCS No  6 Applied at Node # 27 (lbf)                                                      
  7    Fx  RCS No  7 Applied at Node # 28 (lbf)                                                      
  8    Fy  RCS No  8 Applied at Node # 28 (lbf)                                                      
  9    Fx  Disturb.  No  9 at Node # 21 (lbf)                                                      
 10    Fy  Disturb.  No 10 at Node # 21 (lbf)                                                      
 11    Fz  Disturb.  No 11 at Node # 21 (lbf)                                                      
 12    Torq-x No  1 CMG Applied at Node # 10 (ft-lb)                                                    
 13    Torq-y No  2 CMG Applied at Node # 10 (ft-lb)                                                    
 14    Torq-z No  3 CMG Applied at Node # 10 (ft-lb)                                                    
 15    Torq-x No  4 Gimbal Dist. at Node #  1 (ft-lb)                                                    
 16    Torq-y No  5 Gimbal Dist. at Node #  1 (ft-lb)                                                    
 17    Torq-z No  6 Gimbal Dist. at Node #  1 (ft-lb)                                                    
                                                                                                    
Outputs =  15                                                                                       
  1    X-Accelerat. at Sensors, Node #  9 (ft)                                                        
  2    Y-Accelerat. at Sensors, Node #  9 (ft)                                                        
  3    Z-Accelerat. at Sensors, Node #  9 (ft)                                                        
  4    X-Accelerat. at Right Boom End, Node #  5 (ft)                                                        
  5    Z-Accelerat. at Right Boom End, Node #  5 (ft)                                                        
  6    X-Accelerat. at Left Boom End, Node # 18 (ft)                                                        
  7    Z-Accelerat. at Left Boom End, Node # 18 (ft)                                                        
  8    X-Rot. Rate  at Sensors, Node #  9 (radian)                                                    
  9    Y-Rot. Rate  at Sensors, Node #  9 (radian)                                                    
 10    Z-Rot. Rate  at Sensors, Node #  9 (radian)                                                    
 11    X-Rot. Rate  at Antena Bot-Left, Node # 24 (radian)                                                    
 12    Y-Rot. Rate  at Antena Bot-Left, Node # 24 (radian)                                                    
 13    Z-Rot. Rate  at Antena Bot-Left, Node # 24 (radian)                                                    
 14    Y-Rot.Accel. at Right Joint, Node #  7 (radian)                                                    
 15    Y-Rot.Accel. at Left Joint, Node # 16 (radian)                                                    
                                                                                                    
States  =  76                                                                                       
  1    Flex Mode #  1 Generalized Displacem eta(  1) (ft)                                           
  2    Flex Mode #  1 eta(  1)-dot    (ft/sec)                                                      
  3    Flex Mode #  2 Generalized Displacem eta(  2) (ft)                                           
  4    Flex Mode #  2 eta(  2)-dot    (ft/sec)                                                      
  5    Flex Mode #  3 Generalized Displacem eta(  3) (ft)                                           
  6    Flex Mode #  3 eta(  3)-dot    (ft/sec)                                                      
  7    Flex Mode #  4 Generalized Displacem eta(  4) (ft)                                           
  8    Flex Mode #  4 eta(  4)-dot    (ft/sec)                                                      
  9    Flex Mode #  5 Generalized Displacem eta(  5) (ft)                                           
 10    Flex Mode #  5 eta(  5)-dot    (ft/sec)                                                      
 11    Flex Mode #  6 Generalized Displacem eta(  6) (ft)                                           
 12    Flex Mode #  6 eta(  6)-dot    (ft/sec)                                                      
 13    Flex Mode #  7 Generalized Displacem eta(  7) (ft)                                           
 14    Flex Mode #  7 eta(  7)-dot    (ft/sec)                                                      
 15    Flex Mode #  8 Generalized Displacem eta(  8) (ft)                                           
 16    Flex Mode #  8 eta(  8)-dot    (ft/sec)                                                      
 17    Flex Mode #  9 Generalized Displacem eta(  9) (ft)                                           
 18    Flex Mode #  9 eta(  9)-dot    (ft/sec)                                                      
 19    Flex Mode # 10 Generalized Displacem eta( 10) (ft)                                           
 20    Flex Mode # 10 eta( 10)-dot    (ft/sec)                                                      
 21    Flex Mode # 11 Generalized Displacem eta( 11) (ft)                                           
 22    Flex Mode # 11 eta( 11)-dot    (ft/sec)                                                      
 23    Flex Mode # 12 Generalized Displacem eta( 12) (ft)                                           
 24    Flex Mode # 12 eta( 12)-dot    (ft/sec)                                                      
 25    Flex Mode # 13 Generalized Displacem eta( 13) (ft)                                           
 26    Flex Mode # 13 eta( 13)-dot    (ft/sec)                                                      
 27    Flex Mode # 14 Generalized Displacem eta( 14) (ft)                                           
 28    Flex Mode # 14 eta( 14)-dot    (ft/sec)                                                      
 29    Flex Mode # 15 Generalized Displacem eta( 15) (ft)                                           
 30    Flex Mode # 15 eta( 15)-dot    (ft/sec)                                                      
 31    Flex Mode # 16 Generalized Displacem eta( 16) (ft)                                           
 32    Flex Mode # 16 eta( 16)-dot    (ft/sec)                                                      
 33    Flex Mode # 17 Generalized Displacem eta( 17) (ft)                                           
 34    Flex Mode # 17 eta( 17)-dot    (ft/sec)                                                      
 35    Flex Mode # 18 Generalized Displacem eta( 18) (ft)                                           
 36    Flex Mode # 18 eta( 18)-dot    (ft/sec)                                                      
 37    Flex Mode # 19 Generalized Displacem eta( 19) (ft)                                           
 38    Flex Mode # 19 eta( 19)-dot    (ft/sec)                                                      
 39    Flex Mode # 20 Generalized Displacem eta( 20) (ft)                                           
 40    Flex Mode # 20 eta( 20)-dot    (ft/sec)                                                      
 41    Flex Mode # 21 Generalized Displacem eta( 21) (ft)                                           
 42    Flex Mode # 21 eta( 21)-dot    (ft/sec)                                                      
 43    Flex Mode # 22 Generalized Displacem eta( 22) (ft)                                           
 44    Flex Mode # 22 eta( 22)-dot    (ft/sec)                                                      
 45    Flex Mode # 23 Generalized Displacem eta( 23) (ft)                                           
 46    Flex Mode # 23 eta( 23)-dot    (ft/sec)                                                      
 47    Flex Mode # 24 Generalized Displacem eta( 24) (ft)                                           
 48    Flex Mode # 24 eta( 24)-dot    (ft/sec)                                                      
 49    Flex Mode # 25 Generalized Displacem eta( 25) (ft)                                           
 50    Flex Mode # 25 eta( 25)-dot    (ft/sec)                                                      
 51    Flex Mode # 26 Generalized Displacem eta( 26) (ft)                                           
 52    Flex Mode # 26 eta( 26)-dot    (ft/sec)                                                      
 53    Flex Mode # 27 Generalized Displacem eta( 27) (ft)                                           
 54    Flex Mode # 27 eta( 27)-dot    (ft/sec)                                                      
 55    Flex Mode # 28 Generalized Displacem eta( 28) (ft)                                           
 56    Flex Mode # 28 eta( 28)-dot    (ft/sec)                                                      
 57    Flex Mode # 29 Generalized Displacem eta( 29) (ft)                                           
 58    Flex Mode # 29 eta( 29)-dot    (ft/sec)                                                      
 59    Flex Mode # 30 Generalized Displacem eta( 30) (ft)                                           
 60    Flex Mode # 30 eta( 30)-dot    (ft/sec)                                                      
 61    Flex Mode # 31 Generalized Displacem eta( 31) (ft)                                           
 62    Flex Mode # 31 eta( 31)-dot    (ft/sec)                                                      
 63    Flex Mode # 32 Generalized Displacem eta( 32) (ft)                                           
 64    Flex Mode # 32 eta( 32)-dot    (ft/sec)                                                      
 65    Flex Mode # 33 Generalized Displacem eta( 33) (ft)                                           
 66    Flex Mode # 33 eta( 33)-dot    (ft/sec)                                                      
 67    Flex Mode # 34 Generalized Displacem eta( 34) (ft)                                           
 68    Flex Mode # 34 eta( 34)-dot    (ft/sec)                                                      
 69    Flex Mode # 35 Generalized Displacem eta( 35) (ft)                                           
 70    Flex Mode # 35 eta( 35)-dot    (ft/sec)                                                      
 71    Flex Mode # 36 Generalized Displacem eta( 36) (ft)                                           
 72    Flex Mode # 36 eta( 36)-dot    (ft/sec)                                                      
 73    Flex Mode # 37 Generalized Displacem eta( 37) (ft)                                           
 74    Flex Mode # 37 eta( 37)-dot    (ft/sec)                                                      
 75    Flex Mode # 38 Generalized Displacem eta( 38) (ft)                                           
 76    Flex Mode # 38 eta( 38)-dot    (ft/sec)                                                      
-----------------------------------------------------------------------------------------------------------------------
FLEXIBLE SPACECRAFT FE MODEL ...
Rigid Body Space Structure                                          

Number of Input Forces applied on flex structure nodes (N_force)                         : 11
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  1    25      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  2    25      0.000      -1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  3    26      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  4    26      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  5    27      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  6    27      0.000      -1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  7    28      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  8    28      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  9    21      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     : 10    21      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     : 11    21      0.000       0.000       1.000    

Number of Input Torques applied on flex structure nodes (N_torque)                       :  6
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  1    10      1.000       0.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  2    10      0.000       1.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  3    10      0.000       0.000       1.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  4     1      1.000       0.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  5     1      0.000       1.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  6     1      0.000       0.000       1.000    

Number of Linear Sensors Measuring Translations on the flex structure nodes (N_transl)   :  7
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  1     9      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  2     9      2    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  3     9      3    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  4     5      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  5     5      3    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  6    18      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  7    18      3    3

Number of Gyro Sensors Measuring Rotations on the flex structure nodes (N_rotat)         :  8
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  1     9      1    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  2     9      2    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  3     9      3    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  4    24      1    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  5    24      2    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  6    24      3    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  7     7      2    3
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  8    16      2    3

Number of Flexible Modes (max=600), Mode Shapes and Mode Frequencies are included below  :  6

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.97519D-01   0.77610D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Top Right RCS Thruster Assembl      25     0.97519D-01   0.77610D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Top Left RCS Thrusters Assembl      26     0.79657D-01   0.77610D-04  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Top Left RCS Thrusters Assembl      26     0.79657D-01   0.77610D-04  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Right RCS Thruster Asse      27    -0.62938D-01   0.12591D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Right RCS Thruster Asse      27    -0.62938D-01   0.12591D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Left RCS Thrusters Asse      28    -0.80800D-01   0.12591D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Left RCS Thrusters Asse      28    -0.80800D-01   0.12591D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Center Habitat Module               21    -0.12152D-02   0.29089D-02  -0.11831D-01  -0.16357D-06  -0.54342D-03  -0.13610D-03
