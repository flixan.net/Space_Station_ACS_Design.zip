BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing flexible Space Station models
! This batch set creates three state-space models for the Space Station,
! (a) a flex model of 38 modes including 6 rigid-body modes,
! (b) a rigid-body model consisting of the first 6 rigid-body modes, and
! (c) a flex model of 32 modes that excludes the rigid-body modes.
! The systems and matrices are converted to Matlab format
!
Retain Matrix    : Mixing Logic for the Large Flex Space Structure
Retain Matrix    : RCS Angular Accelerations Matrix
Flex Spacecraft  : Large Flex Space Structure, 38 Modes                
Flex Spacecraft  : Rigid Body Space Structure                                          
Flex Spacecraft  : Large Flex Space Structure, 32 Modes, Flex Only
!
To Matlab Format : Large Flex Space Structure, 38 Modes
To Matlab Format : Rigid Body Space Structure
To Matlab Format : Large Flex Space Structure, 32 Modes, Flex Only
To Matlab Format : Mixing Logic for the Large Flex Space Structure
To Matlab Format : RCS Angular Accelerations Matrix
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLEXIBLE SPACECRAFT FE MODEL ...
Large Flex Space Structure, 38 Modes                                                    
! This is a Large Flexible Space Station that uses RCS and CMG for attitude control     
! The Control Moment Gyros provide control torque and they are located at Node 10, 
! The Reaction Control Jets are in Nodes (25,26,27,28) and they fire along x and y
! The Attitude Control Sensors are in Node 9 and they measure rotation rates (roll,pitch,yaw)
! and accelerations along (x, y, z). There are additional nodes for measuring the vehicle 
! sensitivity to disturbances.

Number of Input Forces applied on flex structure nodes (N_force)                         : 11
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  1    25      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  2    25      0.000      -1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  3    26      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  4    26      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  5    27      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  6    27      0.000      -1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  7    28      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  8    28      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     :  9    21      1.000       0.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     : 10    21      0.000       1.000       0.000    
Input Force Number, Node Number (see map), Force Direction unit vector along (x,y,z)     : 11    21      0.000       0.000       1.000    

Number of Input Torques applied on flex structure nodes (N_torque)                       :  6
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  1    10      1.000       0.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  2    10      0.000       1.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  3    10      0.000       0.000       1.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  4     1      1.000       0.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  5     1      0.000       1.000       0.000    
Input Torque Number, Node Number (map), Torque Direction unit vector about (x,y,z)       :  6     1      0.000       0.000       1.000    

Number of Linear Sensors Measuring Translations on the flex structure nodes (N_transl)   :  7
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  1     9      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  2     9      2    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  3     9      3    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  4     5      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  5     5      3    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  6    18      1    3
Translation Sensor Numb, Node Numb, Along (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  7    18      3    3

Number of Gyro Sensors Measuring Rotations on the flex structure nodes (N_rotat)         :  8
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  1     9      1    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  2     9      2    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  3     9      3    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  4    24      1    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  5    24      2    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  6    24      3    2
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  7     7      2    3
Rotation Sensor Numbr, Node Number, About (1=X,2=Y,3=Z), Type (1=Posit,2=Veloc,3=Acceler):  8    16      2    3

Number of Flexible Modes (max=600), Mode Shapes and Mode Frequencies are included below  : 38

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.97519D-01   0.77610D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Top Right RCS Thruster Assembl      25     0.97519D-01   0.77610D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Top Left RCS Thrusters Assembl      26     0.79657D-01   0.77610D-04  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Top Left RCS Thrusters Assembl      26     0.79657D-01   0.77610D-04  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Right RCS Thruster Asse      27    -0.62938D-01   0.12591D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Right RCS Thruster Asse      27    -0.62938D-01   0.12591D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Left RCS Thrusters Asse      28    -0.80800D-01   0.12591D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Left RCS Thrusters Asse      28    -0.80800D-01   0.12591D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Center Habitat Module               21    -0.12152D-02   0.29089D-02  -0.11831D-01  -0.16357D-06  -0.54342D-03  -0.13610D-03
Center Habitat Module               21    -0.12152D-02   0.29089D-02  -0.11831D-01  -0.16357D-06  -0.54342D-03  -0.13610D-03
Center Habitat Module               21    -0.12152D-02   0.29089D-02  -0.11831D-01  -0.16357D-06  -0.54342D-03  -0.13610D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.17290D-01   0.10176D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Keel/Boom Intrsect, CMG       10     0.17290D-01   0.10176D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Keel/Boom Intrsect, CMG       10     0.17290D-01   0.10176D-03  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Payload boom, (top-right)            1     0.10643D+00   0.74926D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Payload boom, (top-right)            1     0.10643D+00   0.74926D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Payload boom, (top-right)            1     0.10643D+00   0.74926D-04  -0.64510D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.19520D-01   0.10176D-03  -0.64777D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Boom (Sensor Assembly)         9     0.19520D-01   0.10176D-03  -0.64777D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Boom (Sensor Assembly)         9     0.19520D-01   0.10176D-03  -0.64777D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Solar Array Boom               5     0.41841D-01   0.10176D-03  -0.67460D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Solar Array Boom               5     0.41841D-01   0.10176D-03  -0.67460D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Left SA Boom, Extreeme End          18    -0.25122D-01   0.10176D-03  -0.59412D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Left SA Boom, Extreeme End          18    -0.25122D-01   0.10176D-03  -0.59412D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.19520D-01   0.10176D-03  -0.64777D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Boom (Sensor Assembly)         9     0.19520D-01   0.10176D-03  -0.64777D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right Boom (Sensor Assembly)         9     0.19520D-01   0.10176D-03  -0.64777D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Payload Boom (Left) Ant      24    -0.89714D-01   0.12859D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Payload Boom (Left) Ant      24    -0.89714D-01   0.12859D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Bottom Payload Boom (Left) Ant      24    -0.89714D-01   0.12859D-03  -0.62363D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Right SA Boom, Outboard the Hi       7     0.27333D-01   0.10176D-03  -0.65716D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03
Left SA Boom, Outboard the Hin      16    -0.10614D-01   0.10176D-03  -0.61156D-03  -0.16357D-06  -0.54342D-03  -0.13610D-03

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.25299D-01  -0.28444D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Top Right RCS Thruster Assembl      25    -0.25299D-01  -0.28444D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Top Left RCS Thrusters Assembl      26    -0.19480D-01  -0.28444D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Top Left RCS Thrusters Assembl      26    -0.19480D-01  -0.28444D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Right RCS Thruster Asse      27    -0.33597D-01  -0.31385D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Right RCS Thruster Asse      27    -0.33597D-01  -0.31385D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Left RCS Thrusters Asse      28    -0.27778D-01  -0.31385D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Left RCS Thrusters Asse      28    -0.27778D-01  -0.31385D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Center Habitat Module               21    -0.27659D-01  -0.39255D-02  -0.64135D-03   0.99614D-06  -0.28103D-04   0.44345D-04
Center Habitat Module               21    -0.27659D-01  -0.39255D-02  -0.64135D-03   0.99614D-06  -0.28103D-04   0.44345D-04
Center Habitat Module               21    -0.27659D-01  -0.39255D-02  -0.64135D-03   0.99614D-06  -0.28103D-04   0.44345D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.29448D-01  -0.29915D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Keel/Boom Intrsect, CMG       10    -0.29448D-01  -0.29915D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Keel/Boom Intrsect, CMG       10    -0.29448D-01  -0.29915D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Payload boom, (top-right)            1    -0.24838D-01  -0.28280D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Payload boom, (top-right)            1    -0.24838D-01  -0.28280D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Payload boom, (top-right)            1    -0.24838D-01  -0.28280D-02  -0.91867D-05   0.99616D-06  -0.28103D-04   0.44345D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.30175D-01  -0.29915D-02   0.71336D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Boom (Sensor Assembly)         9    -0.30175D-01  -0.29915D-02   0.71336D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Boom (Sensor Assembly)         9    -0.30175D-01  -0.29915D-02   0.71336D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Solar Array Boom               5    -0.37447D-01  -0.29915D-02   0.17050D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Right Solar Array Boom               5    -0.37447D-01  -0.29915D-02   0.17050D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Left SA Boom, Extreeme End          18    -0.15630D-01  -0.29915D-02  -0.31960D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Left SA Boom, Extreeme End          18    -0.15630D-01  -0.29915D-02  -0.31960D-03   0.99616D-06  -0.28103D-04   0.44345D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.30175D-01  -0.29915D-02   0.71336D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Boom (Sensor Assembly)         9    -0.30175D-01  -0.29915D-02   0.71336D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Right Boom (Sensor Assembly)         9    -0.30175D-01  -0.29915D-02   0.71336D-05   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Payload Boom (Left) Ant      24    -0.28239D-01  -0.31549D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Payload Boom (Left) Ant      24    -0.28239D-01  -0.31549D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Bottom Payload Boom (Left) Ant      24    -0.28239D-01  -0.31549D-02  -0.13992D-03   0.99616D-06  -0.28103D-04   0.44345D-04
Right SA Boom, Outboard the Hi       7    -0.32720D-01  -0.29915D-02   0.64315D-04   0.99616D-06  -0.28103D-04   0.44345D-04
Left SA Boom, Outboard the Hin      16    -0.20357D-01  -0.29915D-02  -0.21342D-03   0.99616D-06  -0.28103D-04   0.44345D-04

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.11628D-01  -0.25434D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Top Right RCS Thruster Assembl      25     0.11628D-01  -0.25434D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Top Left RCS Thrusters Assembl      26     0.12974D-01  -0.25434D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Top Left RCS Thrusters Assembl      26     0.12974D-01  -0.25434D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Right RCS Thruster Asse      27    -0.37816D-02  -0.27949D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Right RCS Thruster Asse      27    -0.37816D-02  -0.27949D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Left RCS Thrusters Asse      28    -0.24355D-02  -0.27949D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Left RCS Thrusters Asse      28    -0.24355D-02  -0.27949D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Center Habitat Module               21     0.33928D-02  -0.27079D-01  -0.67989D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Center Habitat Module               21     0.33928D-02  -0.27079D-01  -0.67989D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Center Habitat Module               21     0.33928D-02  -0.27079D-01  -0.67989D-03   0.85205D-05  -0.52187D-04   0.10258D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.39230D-02  -0.26692D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Keel/Boom Intrsect, CMG       10     0.39230D-02  -0.26692D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Keel/Boom Intrsect, CMG       10     0.39230D-02  -0.26692D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Payload boom, (top-right)            1     0.12484D-01  -0.25294D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Payload boom, (top-right)            1     0.12484D-01  -0.25294D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Payload boom, (top-right)            1     0.12484D-01  -0.25294D-01   0.85057D-03   0.85205D-05  -0.52187D-04   0.10258D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.37550D-02  -0.26692D-01   0.99017D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Boom (Sensor Assembly)         9     0.37550D-02  -0.26692D-01   0.99017D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Boom (Sensor Assembly)         9     0.37550D-02  -0.26692D-01   0.99017D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Solar Array Boom               5     0.20727D-02  -0.26692D-01   0.23875D-02   0.85205D-05  -0.52187D-04   0.10258D-04
Right Solar Array Boom               5     0.20727D-02  -0.26692D-01   0.23875D-02   0.85205D-05  -0.52187D-04   0.10258D-04
Left SA Boom, Extreeme End          18     0.71195D-02  -0.26692D-01  -0.18045D-02   0.85205D-05  -0.52187D-04   0.10258D-04
Left SA Boom, Extreeme End          18     0.71195D-02  -0.26692D-01  -0.18045D-02   0.85205D-05  -0.52187D-04   0.10258D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.37550D-02  -0.26692D-01   0.99017D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Boom (Sensor Assembly)         9     0.37550D-02  -0.26692D-01   0.99017D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right Boom (Sensor Assembly)         9     0.37550D-02  -0.26692D-01   0.99017D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Payload Boom (Left) Ant      24    -0.32916D-02  -0.28089D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Payload Boom (Left) Ant      24    -0.32916D-02  -0.28089D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Bottom Payload Boom (Left) Ant      24    -0.32916D-02  -0.28089D-01  -0.26759D-03   0.85205D-05  -0.52187D-04   0.10258D-04
Right SA Boom, Outboard the Hi       7     0.31662D-02  -0.26692D-01   0.14793D-02   0.85205D-05  -0.52187D-04   0.10258D-04
Left SA Boom, Outboard the Hin      16     0.60260D-02  -0.26692D-01  -0.89628D-03   0.85205D-05  -0.52187D-04   0.10258D-04

MODE#  4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.11515D-01   0.60616D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Top Right RCS Thruster Assembl      25     0.11515D-01   0.60616D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Top Left RCS Thrusters Assembl      26     0.51571D-01   0.60616D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Top Left RCS Thrusters Assembl      26     0.51571D-01   0.60616D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Right RCS Thruster Asse      27    -0.40785D-01   0.60122D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Right RCS Thruster Asse      27    -0.40785D-01   0.60122D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Left RCS Thrusters Asse      28    -0.72940D-03   0.60122D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Left RCS Thrusters Asse      28    -0.72940D-03   0.60122D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Center Habitat Module               21    -0.19812D-02  -0.25420D-03  -0.82411D-02   0.16703D-06  -0.17712D-03   0.30523D-03
Center Habitat Module               21    -0.19812D-02  -0.25420D-03  -0.82411D-02   0.16703D-06  -0.17712D-03   0.30523D-03
Center Habitat Module               21    -0.19812D-02  -0.25420D-03  -0.82411D-02   0.16703D-06  -0.17712D-03   0.30523D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.14635D-01   0.60369D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Keel/Boom Intrsect, CMG       10    -0.14635D-01   0.60369D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Keel/Boom Intrsect, CMG       10    -0.14635D-01   0.60369D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Payload boom, (top-right)            1     0.14421D-01   0.60643D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Payload boom, (top-right)            1     0.14421D-01   0.60643D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Payload boom, (top-right)            1     0.14421D-01   0.60643D-02  -0.45834D-02   0.16704D-06  -0.17712D-03   0.30523D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.19636D-01   0.60369D-02  -0.45807D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Boom (Sensor Assembly)         9    -0.19636D-01   0.60369D-02  -0.45807D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Boom (Sensor Assembly)         9    -0.19636D-01   0.60369D-02  -0.45807D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Solar Array Boom               5    -0.69693D-01   0.60369D-02  -0.45533D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Solar Array Boom               5    -0.69693D-01   0.60369D-02  -0.45533D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Left SA Boom, Extreeme End          18     0.80479D-01   0.60369D-02  -0.46354D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Left SA Boom, Extreeme End          18     0.80479D-01   0.60369D-02  -0.46354D-02   0.16704D-06  -0.17712D-03   0.30523D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.19636D-01   0.60369D-02  -0.45807D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Boom (Sensor Assembly)         9    -0.19636D-01   0.60369D-02  -0.45807D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right Boom (Sensor Assembly)         9    -0.19636D-01   0.60369D-02  -0.45807D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Payload Boom (Left) Ant      24    -0.36350D-02   0.60095D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Payload Boom (Left) Ant      24    -0.36350D-02   0.60095D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Bottom Payload Boom (Left) Ant      24    -0.36350D-02   0.60095D-02  -0.46053D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Right SA Boom, Outboard the Hi       7    -0.37156D-01   0.60369D-02  -0.45711D-02   0.16704D-06  -0.17712D-03   0.30523D-03
Left SA Boom, Outboard the Hin      16     0.47942D-01   0.60369D-02  -0.46176D-02   0.16704D-06  -0.17712D-03   0.30523D-03

MODE#  5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.31824D-01  -0.76100D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Top Right RCS Thruster Assembl      25     0.31824D-01  -0.76100D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Top Left RCS Thrusters Assembl      26     0.37458D-01  -0.76100D-03   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Top Left RCS Thrusters Assembl      26     0.37458D-01  -0.76100D-03   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Right RCS Thruster Asse      27    -0.30345D-01   0.27263D-02   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Right RCS Thruster Asse      27    -0.30345D-01   0.27263D-02   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Left RCS Thrusters Asse      28    -0.24712D-01   0.27263D-02   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Left RCS Thrusters Asse      28    -0.24712D-01   0.27263D-02   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Center Habitat Module               21    -0.13175D-02   0.34244D-03   0.23521D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Center Habitat Module               21    -0.13175D-02   0.34244D-03   0.23521D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Center Habitat Module               21    -0.13175D-02   0.34244D-03   0.23521D-01  -0.11810D-04  -0.21055D-03   0.42928D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.73937D-03   0.98267D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Keel/Boom Intrsect, CMG       10     0.73937D-03   0.98267D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Keel/Boom Intrsect, CMG       10     0.73937D-03   0.98267D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Payload boom, (top-right)            1     0.35278D-01  -0.95474D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Payload boom, (top-right)            1     0.35278D-01  -0.95474D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Payload boom, (top-right)            1     0.35278D-01  -0.95474D-03   0.27228D-01  -0.11810D-04  -0.21055D-03   0.42928D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.36064D-04   0.98267D-03   0.27034D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Boom (Sensor Assembly)         9     0.36064D-04   0.98267D-03   0.27034D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Boom (Sensor Assembly)         9     0.36064D-04   0.98267D-03   0.27034D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Solar Array Boom               5    -0.70041D-02   0.98267D-03   0.25097D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Solar Array Boom               5    -0.70041D-02   0.98267D-03   0.25097D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Left SA Boom, Extreeme End          18     0.14116D-01   0.98267D-03   0.30908D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Left SA Boom, Extreeme End          18     0.14116D-01   0.98267D-03   0.30908D-01  -0.11810D-04  -0.21055D-03   0.42928D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.36064D-04   0.98267D-03   0.27034D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Boom (Sensor Assembly)         9     0.36064D-04   0.98267D-03   0.27034D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right Boom (Sensor Assembly)         9     0.36064D-04   0.98267D-03   0.27034D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Payload Boom (Left) Ant      24    -0.28166D-01   0.29201D-02   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Payload Boom (Left) Ant      24    -0.28166D-01   0.29201D-02   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Bottom Payload Boom (Left) Ant      24    -0.28166D-01   0.29201D-02   0.28777D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Right SA Boom, Outboard the Hi       7    -0.24281D-02   0.98267D-03   0.26356D-01  -0.11810D-04  -0.21055D-03   0.42928D-04
Left SA Boom, Outboard the Hin      16     0.95404D-02   0.98267D-03   0.29649D-01  -0.11810D-04  -0.21055D-03   0.42928D-04

MODE#  6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    0.0000       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.16221D-03  -0.53251D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Top Right RCS Thruster Assembl      25     0.16221D-03  -0.53251D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Top Left RCS Thrusters Assembl      26     0.42791D-03  -0.53251D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Top Left RCS Thrusters Assembl      26     0.42791D-03  -0.53251D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Right RCS Thruster Asse      27    -0.37732D-03   0.41969D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Right RCS Thruster Asse      27    -0.37732D-03   0.41969D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Left RCS Thrusters Asse      28    -0.11162D-03   0.41969D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Left RCS Thrusters Asse      28    -0.11162D-03   0.41969D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Center Habitat Module               21    -0.37099D-04   0.98231D-03  -0.57995D-02  -0.32248D-03  -0.18272D-05   0.20246D-05
Center Habitat Module               21    -0.37099D-04   0.98231D-03  -0.57995D-02  -0.32248D-03  -0.18272D-05   0.20246D-05
Center Habitat Module               21    -0.37099D-04   0.98231D-03  -0.57995D-02  -0.32248D-03  -0.18272D-05   0.20246D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.10755D-03  -0.56405D-02  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Keel/Boom Intrsect, CMG       10    -0.10755D-03  -0.56405D-02  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Keel/Boom Intrsect, CMG       10    -0.10755D-03  -0.56405D-02  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Payload boom, (top-right)            1     0.19218D-03  -0.58541D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Payload boom, (top-right)            1     0.19218D-03  -0.58541D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Payload boom, (top-right)            1     0.19218D-03  -0.58541D-01  -0.22998D-01  -0.32248D-03  -0.18272D-05   0.20246D-05

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.14072D-03  -0.56405D-02  -0.28282D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Boom (Sensor Assembly)         9    -0.14072D-03  -0.56405D-02  -0.28282D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Boom (Sensor Assembly)         9    -0.14072D-03  -0.56405D-02  -0.28282D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Solar Array Boom               5    -0.47277D-03  -0.56405D-02  -0.81168D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Solar Array Boom               5    -0.47277D-03  -0.56405D-02  -0.81168D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Left SA Boom, Extreeme End          18     0.52336D-03  -0.56405D-02   0.77491D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Left SA Boom, Extreeme End          18     0.52336D-03  -0.56405D-02   0.77491D-01  -0.32248D-03  -0.18272D-05   0.20246D-05

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.14072D-03  -0.56405D-02  -0.28282D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Boom (Sensor Assembly)         9    -0.14072D-03  -0.56405D-02  -0.28282D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right Boom (Sensor Assembly)         9    -0.14072D-03  -0.56405D-02  -0.28282D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Payload Boom (Left) Ant      24    -0.14159D-03   0.47259D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Payload Boom (Left) Ant      24    -0.14159D-03   0.47259D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Bottom Payload Boom (Left) Ant      24    -0.14159D-03   0.47259D-01   0.19322D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Right SA Boom, Outboard the Hi       7    -0.25694D-03  -0.56405D-02  -0.46793D-01  -0.32248D-03  -0.18272D-05   0.20246D-05
Left SA Boom, Outboard the Hin      16     0.30754D-03  -0.56405D-02   0.43116D-01  -0.32248D-03  -0.18272D-05   0.20246D-05

MODE#  7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.0097       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.59628D-02  -0.16325D-04   0.96510D-04   0.42971D-06  -0.33256D-04   0.10894D-04
Top Right RCS Thruster Assembl      25     0.59628D-02  -0.16325D-04   0.96510D-04   0.42971D-06  -0.33256D-04   0.10894D-04
Top Left RCS Thrusters Assembl      26     0.54261D-02  -0.62395D-05   0.74506D-04  -0.10905D-06  -0.31918D-04  -0.18344D-04
Top Left RCS Thrusters Assembl      26     0.54261D-02  -0.62395D-05   0.74506D-04  -0.10905D-06  -0.31918D-04  -0.18344D-04
Bottom Right RCS Thruster Asse      27    -0.35170D-02  -0.59190D-04   0.96566D-04   0.13160D-06  -0.31650D-04   0.15942D-04
Bottom Right RCS Thruster Asse      27    -0.35170D-02  -0.59190D-04   0.96566D-04   0.13160D-06  -0.31650D-04   0.15942D-04
Bottom Left RCS Thrusters Asse      28    -0.32580D-02  -0.58408D-04   0.74465D-04   0.21757D-06  -0.30306D-04  -0.12670D-04
Bottom Left RCS Thrusters Asse      28    -0.32580D-02  -0.58408D-04   0.74465D-04   0.21757D-06  -0.30306D-04  -0.12670D-04
Center Habitat Module               21     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07
Center Habitat Module               21     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07
Center Habitat Module               21     0.29012D-02  -0.26348D-04   0.31307D-04   0.30160D-06  -0.43846D-05  -0.97127D-07

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.11384D-02  -0.58736D-04   0.96470D-04  -0.23552D-06  -0.30827D-04   0.65746D-04
Right Keel/Boom Intrsect, CMG       10     0.11384D-02  -0.58736D-04   0.96470D-04  -0.23552D-06  -0.30827D-04   0.65746D-04
Right Keel/Boom Intrsect, CMG       10     0.11384D-02  -0.58736D-04   0.96470D-04  -0.23552D-06  -0.30827D-04   0.65746D-04
Payload boom, (top-right)            1     0.65085D-02  -0.90302D-05   0.96510D-04   0.38734D-06  -0.33211D-04   0.47438D-05
Payload boom, (top-right)            1     0.65085D-02  -0.90302D-05   0.96510D-04   0.38734D-06  -0.33211D-04   0.47438D-05
Payload boom, (top-right)            1     0.65085D-02  -0.90302D-05   0.96510D-04   0.38734D-06  -0.33211D-04   0.47438D-05

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)         9    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)         9    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Solar Array Boom               5    -0.25921D-01  -0.73995D-04  -0.57584D-04  -0.10458D-05  -0.59467D-04   0.18409D-03
Right Solar Array Boom               5    -0.25921D-01  -0.73995D-04  -0.57584D-04  -0.10458D-05  -0.59467D-04   0.18409D-03
Left SA Boom, Extreeme End          18    -0.26691D-01   0.68332D-05  -0.15103D-03   0.16740D-05  -0.51013D-05  -0.18778D-03
Left SA Boom, Extreeme End          18    -0.26691D-01   0.68332D-05  -0.15103D-03   0.16740D-05  -0.51013D-05  -0.18778D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)         9    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Right Boom (Sensor Assembly)         9    -0.14682D-03  -0.65626D-04   0.90529D-04  -0.37958D-06  -0.33769D-04   0.86246D-04
Bottom Payload Boom (Left) Ant      24    -0.37573D-02  -0.61752D-04   0.74465D-04   0.20537D-06  -0.30390D-04  -0.65014D-05
Bottom Payload Boom (Left) Ant      24    -0.37573D-02  -0.61752D-04   0.74465D-04   0.20537D-06  -0.30390D-04  -0.65014D-05
Bottom Payload Boom (Left) Ant      24    -0.37573D-02  -0.61752D-04   0.74465D-04   0.20537D-06  -0.30390D-04  -0.65014D-05
Right SA Boom, Outboard the Hi       7    -0.69465D-02  -0.72982D-04   0.55435D-04  -0.94096D-06  -0.43517D-04   0.16106D-03
Left SA Boom, Outboard the Hin      16    -0.73250D-02   0.58470D-05   0.12511D-04   0.13222D-05  -0.17820D-04  -0.16469D-03

MODE#  8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.0255       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.16636D-02   0.23609D-02   0.16364D-03   0.27920D-05  -0.16210D-06  -0.20244D-04
Top Right RCS Thruster Assembl      25     0.16636D-02   0.23609D-02   0.16364D-03   0.27920D-05  -0.16210D-06  -0.20244D-04
Top Left RCS Thrusters Assembl      26    -0.11290D-02   0.23621D-02  -0.89259D-04   0.27349D-05  -0.22105D-05  -0.20206D-04
Top Left RCS Thrusters Assembl      26    -0.11290D-02   0.23621D-02  -0.89259D-04   0.27349D-05  -0.22105D-05  -0.20206D-04
Bottom Right RCS Thruster Asse      27     0.14025D-02   0.14285D-02   0.16128D-03   0.20836D-05  -0.18388D-05  -0.21107D-04
Bottom Right RCS Thruster Asse      27     0.14025D-02   0.14285D-02   0.16128D-03   0.20836D-05  -0.18388D-05  -0.21107D-04
Bottom Left RCS Thrusters Asse      28    -0.15075D-02   0.14276D-02  -0.86874D-04   0.20426D-05  -0.21293D-06  -0.20942D-04
Bottom Left RCS Thrusters Asse      28    -0.15075D-02   0.14276D-02  -0.86874D-04   0.20426D-05  -0.21293D-06  -0.20942D-04
Center Habitat Module               21     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04
Center Habitat Module               21     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04
Center Habitat Module               21     0.43853D-03   0.24159D-02  -0.14498D-04  -0.87197D-06  -0.22871D-05  -0.31766D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.16243D-02   0.18219D-02   0.16059D-03   0.37075D-05  -0.69558D-06  -0.16075D-04
Right Keel/Boom Intrsect, CMG       10     0.16243D-02   0.18219D-02   0.16059D-03   0.37075D-05  -0.69558D-06  -0.16075D-04
Right Keel/Boom Intrsect, CMG       10     0.16243D-02   0.18219D-02   0.16059D-03   0.37075D-05  -0.69558D-06  -0.16075D-04
Payload boom, (top-right)            1     0.16659D-02   0.24048D-02   0.16398D-03   0.24851D-05  -0.23060D-06  -0.20718D-04
Payload boom, (top-right)            1     0.16659D-02   0.24048D-02   0.16398D-03   0.24851D-05  -0.23060D-06  -0.20718D-04
Payload boom, (top-right)            1     0.16659D-02   0.24048D-02   0.16398D-03   0.24851D-05  -0.23060D-06  -0.20718D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)         9     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)         9     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Solar Array Boom               5     0.47651D-02   0.18134D-02   0.16250D-02   0.99683D-05   0.45190D-05  -0.22508D-04
Right Solar Array Boom               5     0.47651D-02   0.18134D-02   0.16250D-02   0.99683D-05   0.45190D-05  -0.22508D-04
Left SA Boom, Extreeme End          18    -0.42523D-02   0.18158D-02  -0.18308D-02   0.12542D-04   0.17081D-05  -0.20118D-04
Left SA Boom, Extreeme End          18    -0.42523D-02   0.18158D-02  -0.18308D-02   0.12542D-04   0.17081D-05  -0.20118D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)         9     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Right Boom (Sensor Assembly)         9     0.18624D-02   0.18157D-02   0.23133D-03   0.45811D-05  -0.17928D-06  -0.11725D-04
Bottom Payload Boom (Left) Ant      24    -0.15102D-02   0.13950D-02  -0.86939D-04   0.19784D-05  -0.25955D-06  -0.21548D-04
Bottom Payload Boom (Left) Ant      24    -0.15102D-02   0.13950D-02  -0.86939D-04   0.19784D-05  -0.25955D-06  -0.21548D-04
Bottom Payload Boom (Left) Ant      24    -0.15102D-02   0.13950D-02  -0.86939D-04   0.19784D-05  -0.25955D-06  -0.21548D-04
Right SA Boom, Outboard the Hi       7     0.24906D-02   0.18112D-02   0.58907D-03   0.87566D-05   0.15271D-05  -0.18100D-04
Left SA Boom, Outboard the Hin      16    -0.22204D-02   0.18133D-02  -0.56459D-03   0.10426D-04  -0.15323D-06  -0.16169D-04

MODE#  9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.1385       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.21520D-01   0.11996D-03   0.20542D-03   0.19540D-05  -0.12114D-03   0.26882D-04
Top Right RCS Thruster Assembl      25     0.21520D-01   0.11996D-03   0.20542D-03   0.19540D-05  -0.12114D-03   0.26882D-04
Top Left RCS Thrusters Assembl      26     0.19134D-01   0.15590D-03   0.68635D-04   0.21893D-06  -0.11507D-03  -0.59819D-04
Top Left RCS Thrusters Assembl      26     0.19134D-01   0.15590D-03   0.68635D-04   0.21893D-06  -0.11507D-03  -0.59819D-04
Bottom Right RCS Thruster Asse      27    -0.12744D-01  -0.17813D-03   0.20551D-03   0.20752D-05  -0.11410D-03   0.50047D-04
Bottom Right RCS Thruster Asse      27    -0.12744D-01  -0.17813D-03   0.20551D-03   0.20752D-05  -0.11410D-03   0.50047D-04
Bottom Left RCS Thrusters Asse      28    -0.11483D-01  -0.21760D-03   0.68576D-04   0.13666D-06  -0.10779D-03  -0.33796D-04
Bottom Left RCS Thrusters Asse      28    -0.11483D-01  -0.21760D-03   0.68576D-04   0.13666D-06  -0.10779D-03  -0.33796D-04
Center Habitat Module               21     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06
Center Habitat Module               21     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06
Center Habitat Module               21     0.96508D-02   0.16360D-05   0.38961D-03   0.13028D-05   0.55434D-05  -0.26488D-06

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.40181D-02  -0.20058D-04   0.20510D-03  -0.19664D-05  -0.11022D-03   0.19217D-03
Right Keel/Boom Intrsect, CMG       10     0.40181D-02  -0.20058D-04   0.20510D-03  -0.19664D-05  -0.11022D-03   0.19217D-03
Right Keel/Boom Intrsect, CMG       10     0.40181D-02  -0.20058D-04   0.20510D-03  -0.19664D-05  -0.11022D-03   0.19217D-03
Payload boom, (top-right)            1     0.23508D-01   0.15374D-03   0.20544D-03   0.18090D-05  -0.12094D-03   0.82645D-05
Payload boom, (top-right)            1     0.23508D-01   0.15374D-03   0.20544D-03   0.18090D-05  -0.12094D-03   0.82645D-05
Payload boom, (top-right)            1     0.23508D-01   0.15374D-03   0.20544D-03   0.18090D-05  -0.12094D-03   0.82645D-05

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)         9     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)         9     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Solar Array Boom               5    -0.84761D-01  -0.23417D-04  -0.17658D-02  -0.14712D-04  -0.24150D-03   0.63024D-03
Right Solar Array Boom               5    -0.84761D-01  -0.23417D-04  -0.17658D-02  -0.14712D-04  -0.24150D-03   0.63024D-03
Left SA Boom, Extreeme End          18    -0.87937D-01  -0.32226D-04  -0.25058D-02   0.19339D-04  -0.78053D-06  -0.64594D-03
Left SA Boom, Extreeme End          18    -0.87937D-01  -0.32226D-04  -0.25058D-02   0.19339D-04  -0.78053D-06  -0.64594D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)         9     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Right Boom (Sensor Assembly)         9     0.24294D-03  -0.18969D-04   0.15053D-03  -0.37738D-05  -0.12421D-03   0.24800D-03
Bottom Payload Boom (Left) Ant      24    -0.13261D-01  -0.21790D-03   0.68556D-04   0.26142D-06  -0.10818D-03  -0.15146D-04
Bottom Payload Boom (Left) Ant      24    -0.13261D-01  -0.21790D-03   0.68556D-04   0.26142D-06  -0.10818D-03  -0.15146D-04
Bottom Payload Boom (Left) Ant      24    -0.13261D-01  -0.21790D-03   0.68556D-04   0.26142D-06  -0.10818D-03  -0.15146D-04
Right SA Boom, Outboard the Hi       7    -0.20296D-01  -0.19530D-04  -0.25427D-03  -0.12143D-04  -0.17046D-03   0.53353D-03
Left SA Boom, Outboard the Hin      16    -0.21812D-01  -0.36670D-04  -0.57590D-03   0.15536D-04  -0.54286D-04  -0.54864D-03

MODE# 10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2538       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.14977D-02   0.43879D-03   0.15863D-03   0.10564D-05  -0.41345D-05  -0.22571D-04
Top Right RCS Thruster Assembl      25     0.14977D-02   0.43879D-03   0.15863D-03   0.10564D-05  -0.41345D-05  -0.22571D-04
Top Left RCS Thrusters Assembl      26    -0.17326D-02   0.38784D-03  -0.13343D-03   0.35465D-05   0.70093D-05  -0.21115D-04
Top Left RCS Thrusters Assembl      26    -0.17326D-02   0.38784D-03  -0.13343D-03   0.35465D-05   0.70093D-05  -0.21115D-04
Bottom Right RCS Thruster Asse      27    -0.13642D-02  -0.28102D-03   0.15852D-03   0.10677D-05  -0.41788D-05   0.21874D-04
Bottom Right RCS Thruster Asse      27    -0.13642D-02  -0.28102D-03   0.15852D-03   0.10677D-05  -0.41788D-05   0.21874D-04
Bottom Left RCS Thrusters Asse      28     0.19555D-02  -0.23169D-03  -0.13330D-03   0.34632D-05   0.71946D-05   0.23281D-04
Bottom Left RCS Thrusters Asse      28     0.19555D-02  -0.23169D-03  -0.13330D-03   0.34632D-05   0.71946D-05   0.23281D-04
Center Habitat Module               21    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05
Center Habitat Module               21    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05
Center Habitat Module               21    -0.25408D-03   0.70244D-05  -0.36192D-03   0.35861D-05  -0.14953D-04   0.12452D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.70262D-04   0.78376D-04   0.15821D-03   0.61854D-05  -0.18467D-04  -0.30878D-05
Right Keel/Boom Intrsect, CMG       10     0.70262D-04   0.78376D-04   0.15821D-03   0.61854D-05  -0.18467D-04  -0.30878D-05
Right Keel/Boom Intrsect, CMG       10     0.70262D-04   0.78376D-04   0.15821D-03   0.61854D-05  -0.18467D-04  -0.30878D-05
Payload boom, (top-right)            1     0.15554D-02   0.45363D-03   0.15866D-03   0.12160D-05  -0.35668D-05  -0.24749D-04
Payload boom, (top-right)            1     0.15554D-02   0.45363D-03   0.15866D-03   0.12160D-05  -0.35668D-05  -0.24749D-04
Payload boom, (top-right)            1     0.15554D-02   0.45363D-03   0.15866D-03   0.12160D-05  -0.35668D-05  -0.24749D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)         9     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)         9     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Solar Array Boom               5     0.11135D-02   0.77862D-04   0.40662D-02   0.28942D-04  -0.11890D-03  -0.62441D-05
Right Solar Array Boom               5     0.11135D-02   0.77862D-04   0.40662D-02   0.28942D-04  -0.11890D-03  -0.62441D-05
Left SA Boom, Extreeme End          18     0.11659D-02   0.70474D-04   0.32605D-02  -0.26773D-04   0.15677D-03   0.58862D-05
Left SA Boom, Extreeme End          18     0.11659D-02   0.70474D-04   0.32605D-02  -0.26773D-04   0.15677D-03   0.58862D-05

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)         9     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Right Boom (Sensor Assembly)         9     0.13212D-03   0.78342D-04   0.29013D-03   0.90449D-05  -0.34692D-04  -0.39139D-05
Bottom Payload Boom (Left) Ant      24     0.20635D-02  -0.29091D-03  -0.13332D-03   0.32712D-05   0.66212D-05   0.25441D-04
Bottom Payload Boom (Left) Ant      24     0.20635D-02  -0.29091D-03  -0.13332D-03   0.32712D-05   0.66212D-05   0.25441D-04
Bottom Payload Boom (Left) Ant      24     0.20635D-02  -0.29091D-03  -0.13332D-03   0.32712D-05   0.66212D-05   0.25441D-04
Right SA Boom, Outboard the Hi       7     0.43391D-03   0.78227D-04   0.11330D-02   0.23808D-04  -0.90485D-04  -0.63973D-05
Left SA Boom, Outboard the Hin      16     0.51331D-03   0.70906D-04   0.57598D-03  -0.21047D-04   0.11683D-03   0.64451D-05

MODE# 11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2560       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.37349D-02  -0.25508D-03  -0.77408D-04   0.86584D-05   0.18294D-04  -0.71532D-05
Top Right RCS Thruster Assembl      25    -0.37349D-02  -0.25508D-03  -0.77408D-04   0.86584D-05   0.18294D-04  -0.71532D-05
Top Left RCS Thrusters Assembl      26    -0.43950D-02   0.92241D-04  -0.80463D-04  -0.83148D-05   0.19591D-04  -0.23596D-05
Top Left RCS Thrusters Assembl      26    -0.43950D-02   0.92241D-04  -0.80463D-04  -0.83148D-05   0.19591D-04  -0.23596D-05
Bottom Right RCS Thruster Asse      27     0.70928D-03  -0.62136D-04  -0.77070D-04   0.84158D-05   0.14588D-04  -0.21060D-05
Bottom Right RCS Thruster Asse      27     0.70928D-03  -0.62136D-04  -0.77070D-04   0.84158D-05   0.14588D-04  -0.21060D-05
Bottom Left RCS Thrusters Asse      28     0.74699D-03  -0.39800D-03  -0.80821D-04  -0.78968D-05   0.15763D-04   0.22032D-05
Bottom Left RCS Thrusters Asse      28     0.74699D-03  -0.39800D-03  -0.80821D-04  -0.78968D-05   0.15763D-04   0.22032D-05
Center Habitat Module               21    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05
Center Habitat Module               21    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05
Center Habitat Module               21    -0.27551D-03  -0.85586D-04   0.27645D-02  -0.24038D-05   0.10346D-03  -0.17544D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.13200D-02  -0.17334D-03  -0.77745D-04  -0.27079D-04   0.12276D-04  -0.12158D-04
Right Keel/Boom Intrsect, CMG       10    -0.13200D-02  -0.17334D-03  -0.77745D-04  -0.27079D-04   0.12276D-04  -0.12158D-04
Right Keel/Boom Intrsect, CMG       10    -0.13200D-02  -0.17334D-03  -0.77745D-04  -0.27079D-04   0.12276D-04  -0.12158D-04
Payload boom, (top-right)            1    -0.40377D-02  -0.97049D-04  -0.77362D-04   0.73350D-05   0.18384D-04  -0.65429D-05
Payload boom, (top-right)            1    -0.40377D-02  -0.97049D-04  -0.77362D-04   0.73350D-05   0.18384D-04  -0.65429D-05
Payload boom, (top-right)            1    -0.40377D-02  -0.97049D-04  -0.77362D-04   0.73350D-05   0.18384D-04  -0.65429D-05

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)         9    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)         9    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Solar Array Boom               5     0.37620D-02  -0.16761D-03  -0.24578D-01  -0.18721D-03  -0.12186D-03  -0.34614D-04
Right Solar Array Boom               5     0.37620D-02  -0.16761D-03  -0.24578D-01  -0.18721D-03  -0.12186D-03  -0.34614D-04
Left SA Boom, Extreeme End          18     0.35787D-02  -0.11463D-03  -0.25536D-01   0.19423D-03  -0.99577D-04   0.38032D-04
Left SA Boom, Extreeme End          18     0.35787D-02  -0.11463D-03  -0.25536D-01   0.19423D-03  -0.99577D-04   0.38032D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)         9    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Right Boom (Sensor Assembly)         9    -0.10818D-02  -0.17289D-03  -0.74281D-03  -0.47240D-04  -0.87889D-05  -0.15527D-04
Bottom Payload Boom (Left) Ant      24     0.10049D-02  -0.25136D-03  -0.80924D-04  -0.67715D-05   0.15712D-04   0.15324D-05
Bottom Payload Boom (Left) Ant      24     0.10049D-02  -0.25136D-03  -0.80924D-04  -0.67715D-05   0.15712D-04   0.15324D-05
Bottom Payload Boom (Left) Ant      24     0.10049D-02  -0.25136D-03  -0.80924D-04  -0.67715D-05   0.15712D-04   0.15324D-05
Right SA Boom, Outboard the Hi       7     0.17278D-03  -0.17119D-03  -0.57104D-02  -0.15054D-03  -0.81042D-04  -0.30762D-04
Left SA Boom, Outboard the Hin      16    -0.31205D-03  -0.11786D-03  -0.59527D-02   0.15638D-03  -0.60744D-04   0.31811D-04

MODE# 12/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2724       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.25094D-02  -0.53751D-03  -0.72885D-04  -0.11269D-05   0.13908D-05  -0.38244D-04
Top Right RCS Thruster Assembl      25     0.25094D-02  -0.53751D-03  -0.72885D-04  -0.11269D-05   0.13908D-05  -0.38244D-04
Top Left RCS Thrusters Assembl      26    -0.25847D-02  -0.57763D-03  -0.64538D-04   0.83348D-06   0.19435D-05  -0.38585D-04
Top Left RCS Thrusters Assembl      26    -0.25847D-02  -0.57763D-03  -0.64538D-04   0.83348D-06   0.19435D-05  -0.38585D-04
Bottom Right RCS Thruster Asse      27     0.31036D-02  -0.61407D-03  -0.71777D-04  -0.75748D-06   0.27646D-05  -0.39131D-04
Bottom Right RCS Thruster Asse      27     0.31036D-02  -0.61407D-03  -0.71777D-04  -0.75748D-06   0.27646D-05  -0.39131D-04
Bottom Left RCS Thrusters Asse      28    -0.21025D-02  -0.57532D-03  -0.65659D-04   0.11240D-05   0.17549D-05  -0.39250D-04
Bottom Left RCS Thrusters Asse      28    -0.21025D-02  -0.57532D-03  -0.65659D-04   0.11240D-05   0.17549D-05  -0.39250D-04
Center Habitat Module               21     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04
Center Habitat Module               21     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04
Center Habitat Module               21     0.69755D-03   0.32513D-03  -0.28454D-03  -0.99508D-07  -0.61006D-05  -0.44971D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.27086D-02  -0.53892D-03  -0.72511D-04   0.34288D-05   0.17716D-05  -0.35293D-04
Right Keel/Boom Intrsect, CMG       10     0.27086D-02  -0.53892D-03  -0.72511D-04   0.34288D-05   0.17716D-05  -0.35293D-04
Right Keel/Boom Intrsect, CMG       10     0.27086D-02  -0.53892D-03  -0.72511D-04   0.34288D-05   0.17716D-05  -0.35293D-04
Payload boom, (top-right)            1     0.24861D-02  -0.55784D-03  -0.72921D-04  -0.95111D-06   0.14206D-05  -0.38594D-04
Payload boom, (top-right)            1     0.24861D-02  -0.55784D-03  -0.72921D-04  -0.95111D-06   0.14206D-05  -0.38594D-04
Payload boom, (top-right)            1     0.24861D-02  -0.55784D-03  -0.72921D-04  -0.95111D-06   0.14206D-05  -0.38594D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)         9     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)         9     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Solar Array Boom               5     0.10629D-01  -0.54165D-03   0.30329D-02   0.23795D-04   0.14000D-04  -0.54900D-04
Right Solar Array Boom               5     0.10629D-01  -0.54165D-03   0.30329D-02   0.23795D-04   0.14000D-04  -0.54900D-04
Left SA Boom, Extreeme End          18    -0.10597D-01  -0.54799D-03   0.26902D-02  -0.21128D-04   0.13478D-04  -0.57230D-04
Left SA Boom, Extreeme End          18    -0.10597D-01  -0.54799D-03   0.26902D-02  -0.21128D-04   0.13478D-04  -0.57230D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)         9     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Right Boom (Sensor Assembly)         9     0.32639D-02  -0.53936D-03   0.11325D-04   0.59646D-05   0.25326D-05  -0.34327D-04
Bottom Payload Boom (Left) Ant      24    -0.20726D-02  -0.59520D-03  -0.65753D-04   0.90138D-06   0.18097D-05  -0.39599D-04
Bottom Payload Boom (Left) Ant      24    -0.20726D-02  -0.59520D-03  -0.65753D-04   0.90138D-06   0.18097D-05  -0.39599D-04
Bottom Payload Boom (Left) Ant      24    -0.20726D-02  -0.59520D-03  -0.65753D-04   0.90138D-06   0.18097D-05  -0.39599D-04
Right SA Boom, Outboard the Hi       7     0.52319D-02  -0.54060D-03   0.63868D-03   0.19073D-04   0.50495D-05  -0.42420D-04
Left SA Boom, Outboard the Hin      16    -0.49498D-02  -0.54700D-03   0.56464D-03  -0.16926D-04   0.46144D-05  -0.44708D-04

MODE# 13/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2905       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.10428D-01   0.23320D-03  -0.90669D-03  -0.85122D-05   0.70948D-04  -0.10066D-04
Top Right RCS Thruster Assembl      25    -0.10428D-01   0.23320D-03  -0.90669D-03  -0.85122D-05   0.70948D-04  -0.10066D-04
Top Left RCS Thrusters Assembl      26    -0.92193D-02  -0.99763D-04  -0.86461D-03   0.77509D-05   0.68353D-04   0.26814D-04
Top Left RCS Thrusters Assembl      26    -0.92193D-02  -0.99763D-04  -0.86461D-03   0.77509D-05   0.68353D-04   0.26814D-04
Bottom Right RCS Thruster Asse      27     0.99710D-02   0.80726D-04  -0.90722D-03  -0.83225D-05   0.71850D-04  -0.19963D-04
Bottom Right RCS Thruster Asse      27     0.99710D-02   0.80726D-04  -0.90722D-03  -0.83225D-05   0.71850D-04  -0.19963D-04
Bottom Left RCS Thrusters Asse      28     0.95555D-02   0.40312D-03  -0.86426D-03   0.73322D-05   0.68797D-04   0.14665D-04
Bottom Left RCS Thrusters Asse      28     0.95555D-02   0.40312D-03  -0.86426D-03   0.73322D-05   0.68797D-04   0.14665D-04
Center Habitat Module               21    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05
Center Habitat Module               21    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05
Center Habitat Module               21    -0.26475D-02   0.92733D-04  -0.22172D-02   0.88795D-06  -0.24934D-04   0.14087D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.27553D-03   0.16845D-03  -0.90551D-03   0.26039D-04   0.62764D-04  -0.79699D-04
Right Keel/Boom Intrsect, CMG       10    -0.27553D-03   0.16845D-03  -0.90551D-03   0.26039D-04   0.62764D-04  -0.79699D-04
Right Keel/Boom Intrsect, CMG       10    -0.27553D-03   0.16845D-03  -0.90551D-03   0.26039D-04   0.62764D-04  -0.79699D-04
Payload boom, (top-right)            1    -0.11594D-01   0.77959D-04  -0.90675D-03  -0.72646D-05   0.70882D-04  -0.21725D-05
Payload boom, (top-right)            1    -0.11594D-01   0.77959D-04  -0.90675D-03  -0.72646D-05   0.70882D-04  -0.21725D-05
Payload boom, (top-right)            1    -0.11594D-01   0.77959D-04  -0.90675D-03  -0.72646D-05   0.70882D-04  -0.21725D-05

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)         9     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)         9     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Solar Array Boom               5     0.40195D-01   0.16692D-03   0.22993D-01   0.18282D-03   0.12510D-03  -0.29818D-03
Right Solar Array Boom               5     0.40195D-01   0.16692D-03   0.22993D-01   0.18282D-03   0.12510D-03  -0.29818D-03
Left SA Boom, Extreeme End          18     0.42191D-01   0.10951D-03   0.23745D-01  -0.18841D-03   0.45551D-05   0.30821D-03
Left SA Boom, Extreeme End          18     0.42191D-01   0.10951D-03   0.23745D-01  -0.18841D-03   0.45551D-05   0.30821D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)         9     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Right Boom (Sensor Assembly)         9     0.12863D-02   0.16821D-03  -0.26349D-03   0.45697D-04   0.67474D-04  -0.10410D-03
Bottom Payload Boom (Left) Ant      24     0.10691D-01   0.26663D-03  -0.86424D-03   0.62207D-05   0.69020D-04   0.68140D-05
Bottom Payload Boom (Left) Ant      24     0.10691D-01   0.26663D-03  -0.86424D-03   0.62207D-05   0.69020D-04   0.68140D-05
Bottom Payload Boom (Left) Ant      24     0.10691D-01   0.26663D-03  -0.86424D-03   0.62207D-05   0.69020D-04   0.68140D-05
Right SA Boom, Outboard the Hi       7     0.10108D-01   0.16784D-03   0.45629D-02   0.14689D-03   0.81721D-04  -0.24154D-03
Left SA Boom, Outboard the Hin      16     0.11087D-01   0.11570D-03   0.47833D-02  -0.15113D-03   0.31925D-04   0.25038D-03

MODE# 14/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.2972       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.13523D-01  -0.12229D-02   0.35921D-02   0.31475D-04  -0.97408D-04  -0.81528D-05
Top Right RCS Thruster Assembl      25     0.13523D-01  -0.12229D-02   0.35921D-02   0.31475D-04  -0.97408D-04  -0.81528D-05
Top Left RCS Thrusters Assembl      26     0.13171D-01   0.95444D-04   0.37043D-02  -0.32934D-04  -0.98884D-04   0.28602D-05
Top Left RCS Thrusters Assembl      26     0.13171D-01   0.95444D-04   0.37043D-02  -0.32934D-04  -0.98884D-04   0.28602D-05
Bottom Right RCS Thruster Asse      27    -0.14040D-01   0.68308D-04   0.35941D-02   0.30606D-04  -0.10083D-03  -0.13868D-04
Bottom Right RCS Thruster Asse      27    -0.14040D-01   0.68308D-04   0.35941D-02   0.30606D-04  -0.10083D-03  -0.13868D-04
Bottom Left RCS Thrusters Asse      28    -0.14999D-01  -0.12052D-02   0.37031D-02  -0.31214D-04  -0.10144D-03   0.39493D-06
Bottom Left RCS Thrusters Asse      28    -0.14999D-01  -0.12052D-02   0.37031D-02  -0.31214D-04  -0.10144D-03   0.39493D-06
Center Habitat Module               21    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05
Center Habitat Module               21    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05
Center Habitat Module               21    -0.89865D-03  -0.37579D-03   0.85094D-02  -0.62707D-05   0.81862D-04  -0.42066D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.81986D-04  -0.63207D-03   0.35878D-02  -0.10523D-03  -0.80440D-04  -0.34210D-04
Right Keel/Boom Intrsect, CMG       10    -0.81986D-04  -0.63207D-03   0.35878D-02  -0.10523D-03  -0.80440D-04  -0.34210D-04
Right Keel/Boom Intrsect, CMG       10    -0.81986D-04  -0.63207D-03   0.35878D-02  -0.10523D-03  -0.80440D-04  -0.34210D-04
Payload boom, (top-right)            1     0.15127D-01  -0.64472D-03   0.35923D-02   0.26570D-04  -0.97567D-04  -0.54545D-05
Payload boom, (top-right)            1     0.15127D-01  -0.64472D-03   0.35923D-02   0.26570D-04  -0.97567D-04  -0.54545D-05
Payload boom, (top-right)            1     0.15127D-01  -0.64472D-03   0.35923D-02   0.26570D-04  -0.97567D-04  -0.54545D-05

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)         9     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)         9     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Solar Array Boom               5     0.16152D-01  -0.60789D-03  -0.92556D-01  -0.73655D-03  -0.10952D-03  -0.11848D-03
Right Solar Array Boom               5     0.16152D-01  -0.60789D-03  -0.92556D-01  -0.73655D-03  -0.10952D-03  -0.11848D-03
Left SA Boom, Extreeme End          18     0.13509D-01  -0.40151D-03  -0.94027D-01   0.74879D-03  -0.15586D-03   0.10637D-03
Left SA Boom, Extreeme End          18     0.13509D-01  -0.40151D-03  -0.94027D-01   0.74879D-03  -0.15586D-03   0.10637D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)         9     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Right Boom (Sensor Assembly)         9     0.58020D-03  -0.63011D-03   0.10079D-02  -0.18385D-03  -0.83005D-04  -0.43787D-04
Bottom Payload Boom (Left) Ant      24    -0.16668D-01  -0.62925D-03   0.37030D-02  -0.26776D-04  -0.10151D-03  -0.24307D-05
Bottom Payload Boom (Left) Ant      24    -0.16668D-01  -0.62925D-03   0.37030D-02  -0.26776D-04  -0.10151D-03  -0.24307D-05
Bottom Payload Boom (Left) Ant      24    -0.16668D-01  -0.62925D-03   0.37030D-02  -0.26776D-04  -0.10151D-03  -0.24307D-05
Right SA Boom, Outboard the Hi       7     0.42008D-02  -0.62285D-03  -0.18390D-01  -0.59083D-03  -0.88298D-04  -0.96673D-04
Left SA Boom, Outboard the Hin      16     0.27398D-02  -0.41523D-03  -0.18617D-01   0.60073D-03  -0.10786D-03   0.86185D-04

MODE# 15/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    1.9041       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.48484D-01  -0.54011D-02  -0.16731D-01  -0.37220D-04  -0.40283D-03  -0.27094D-04
Top Right RCS Thruster Assembl      25     0.48484D-01  -0.54011D-02  -0.16731D-01  -0.37220D-04  -0.40283D-03  -0.27094D-04
Top Left RCS Thrusters Assembl      26     0.43990D-01  -0.56347D-02  -0.12502D-01  -0.25997D-04  -0.41377D-03  -0.33536D-04
Top Left RCS Thrusters Assembl      26     0.43990D-01  -0.56347D-02  -0.12502D-01  -0.25997D-04  -0.41377D-03  -0.33536D-04
Bottom Right RCS Thruster Asse      27    -0.69024D-01   0.20594D-02  -0.16731D-01  -0.35659D-04  -0.49448D-03  -0.55369D-04
Bottom Right RCS Thruster Asse      27    -0.69024D-01   0.20594D-02  -0.16731D-01  -0.35659D-04  -0.49448D-03  -0.55369D-04
Bottom Left RCS Thrusters Asse      28    -0.75610D-01   0.22800D-02  -0.12509D-01  -0.25139D-04  -0.48984D-03  -0.31144D-04
Bottom Left RCS Thrusters Asse      28    -0.75610D-01   0.22800D-02  -0.12509D-01  -0.25139D-04  -0.48984D-03  -0.31144D-04
Center Habitat Module               21     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04
Center Habitat Module               21     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04
Center Habitat Module               21     0.24229D-02   0.76108D-03  -0.74175D-03  -0.69326D-04   0.90388D-03  -0.70981D-04

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.55088D-02  -0.14705D-02  -0.16691D-01   0.29272D-05  -0.28298D-03  -0.40991D-04
Right Keel/Boom Intrsect, CMG       10    -0.55088D-02  -0.14705D-02  -0.16691D-01   0.29272D-05  -0.28298D-03  -0.40991D-04
Right Keel/Boom Intrsect, CMG       10    -0.55088D-02  -0.14705D-02  -0.16691D-01   0.29272D-05  -0.28298D-03  -0.40991D-04
Payload boom, (top-right)            1     0.55136D-01  -0.60291D-02  -0.16732D-01  -0.36306D-04  -0.40396D-03  -0.27071D-04
Payload boom, (top-right)            1     0.55136D-01  -0.60291D-02  -0.16732D-01  -0.36306D-04  -0.40396D-03  -0.27071D-04
Payload boom, (top-right)            1     0.55136D-01  -0.60291D-02  -0.16732D-01  -0.36306D-04  -0.40396D-03  -0.27071D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)         9    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)         9    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Solar Array Boom               5     0.92888D-02  -0.15132D-02   0.30178D-01   0.39827D-03  -0.37013D-03  -0.10219D-03
Right Solar Array Boom               5     0.92888D-02  -0.15132D-02   0.30178D-01   0.39827D-03  -0.37013D-03  -0.10219D-03
Left SA Boom, Extreeme End          18     0.15541D-01  -0.15722D-02   0.15987D-01  -0.22686D-03  -0.51600D-03   0.24137D-03
Left SA Boom, Extreeme End          18     0.15541D-01  -0.15722D-02   0.15987D-01  -0.22686D-03  -0.51600D-03   0.24137D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)         9    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Right Boom (Sensor Assembly)         9    -0.47758D-02  -0.14753D-02  -0.16313D-01   0.41801D-04  -0.30480D-03  -0.47741D-04
Bottom Payload Boom (Left) Ant      24    -0.83711D-01   0.26894D-02  -0.12512D-01  -0.26970D-04  -0.49110D-03  -0.35047D-04
Bottom Payload Boom (Left) Ant      24    -0.83711D-01   0.26894D-02  -0.12512D-01  -0.26970D-04  -0.49110D-03  -0.35047D-04
Bottom Payload Boom (Left) Ant      24    -0.83711D-01   0.26894D-02  -0.12512D-01  -0.26970D-04  -0.49110D-03  -0.35047D-04
Right SA Boom, Outboard the Hi       7    -0.12105D-02  -0.14910D-02  -0.89454D-02   0.29383D-03  -0.34385D-03  -0.87702D-04
Left SA Boom, Outboard the Hin      16    -0.81516D-02  -0.15512D-02  -0.64353D-02  -0.17375D-03  -0.41156D-03   0.17348D-03

MODE# 16/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    2.0858       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.10023D-01  -0.35850D-01  -0.94292D-02  -0.17789D-03   0.10901D-03  -0.27763D-03
Top Right RCS Thruster Assembl      25     0.10023D-01  -0.35850D-01  -0.94292D-02  -0.17789D-03   0.10901D-03  -0.27763D-03
Top Left RCS Thrusters Assembl      26    -0.30071D-01  -0.35819D-01   0.12400D-01  -0.17959D-03   0.80164D-04  -0.28020D-03
Top Left RCS Thrusters Assembl      26    -0.30071D-01  -0.35819D-01   0.12400D-01  -0.17959D-03   0.80164D-04  -0.28020D-03
Bottom Right RCS Thruster Asse      27     0.39367D-01   0.96536D-02  -0.93698D-02  -0.15967D-03   0.11589D-03  -0.29540D-03
Bottom Right RCS Thruster Asse      27     0.39367D-01   0.96536D-02  -0.93698D-02  -0.15967D-03   0.11589D-03  -0.29540D-03
Bottom Left RCS Thrusters Asse      28    -0.34230D-02   0.96384D-02   0.12335D-01  -0.16016D-03   0.13290D-03  -0.30038D-03
Bottom Left RCS Thrusters Asse      28    -0.34230D-02   0.96384D-02   0.12335D-01  -0.16016D-03   0.13290D-03  -0.30038D-03
Center Habitat Module               21     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03
Center Habitat Module               21     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03
Center Habitat Module               21     0.90229D-02   0.30149D-02  -0.29460D-02  -0.21259D-03  -0.13303D-03  -0.62689D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.24017D-01  -0.11178D-01  -0.93641D-02  -0.11276D-03   0.67165D-04  -0.14243D-03
Right Keel/Boom Intrsect, CMG       10     0.24017D-01  -0.11178D-01  -0.93641D-02  -0.11276D-03   0.67165D-04  -0.14243D-03
Right Keel/Boom Intrsect, CMG       10     0.24017D-01  -0.11178D-01  -0.93641D-02  -0.11276D-03   0.67165D-04  -0.14243D-03
Payload boom, (top-right)            1     0.82044D-02  -0.38767D-01  -0.94348D-02  -0.17387D-03   0.10845D-03  -0.29278D-03
Payload boom, (top-right)            1     0.82044D-02  -0.38767D-01  -0.94348D-02  -0.17387D-03   0.10845D-03  -0.29278D-03
Payload boom, (top-right)            1     0.82044D-02  -0.38767D-01  -0.94348D-02  -0.17387D-03   0.10845D-03  -0.29278D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)         9     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)         9     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Solar Array Boom               5    -0.58119D-01  -0.11392D-01   0.29485D-01   0.39398D-03  -0.16864D-03   0.76339D-03
Right Solar Array Boom               5    -0.58119D-01  -0.11392D-01   0.29485D-01   0.39398D-03  -0.16864D-03   0.76339D-03
Left SA Boom, Extreeme End          18     0.52744D-01  -0.11290D-01  -0.33691D-01   0.44231D-03  -0.25805D-03   0.68111D-03
Left SA Boom, Extreeme End          18     0.52744D-01  -0.11290D-01  -0.33691D-01   0.44231D-03  -0.25805D-03   0.68111D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)         9     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Right Boom (Sensor Assembly)         9     0.25435D-01  -0.11207D-01  -0.10730D-01  -0.61339D-04   0.40526D-04  -0.45714D-04
Bottom Payload Boom (Left) Ant      24    -0.11946D-02   0.12296D-01   0.12334D-01  -0.16222D-03   0.13307D-03  -0.31646D-03
Bottom Payload Boom (Left) Ant      24    -0.11946D-02   0.12296D-01   0.12334D-01  -0.16222D-03   0.13307D-03  -0.31646D-03
Bottom Payload Boom (Left) Ant      24    -0.11946D-02   0.12296D-01   0.12334D-01  -0.16222D-03   0.13307D-03  -0.31646D-03
Right SA Boom, Outboard the Hi       7     0.16311D-01  -0.11296D-01  -0.79079D-02   0.25706D-03  -0.38252D-04   0.53256D-03
Left SA Boom, Outboard the Hin      16    -0.13608D-01  -0.11242D-01   0.93416D-02   0.30372D-03  -0.66725D-04   0.47048D-03

MODE# 17/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    2.1921       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.89610D-02  -0.57551D-01  -0.24622D-01  -0.39438D-03  -0.21895D-04   0.14892D-03
Top Right RCS Thruster Assembl      25    -0.89610D-02  -0.57551D-01  -0.24622D-01  -0.39438D-03  -0.21895D-04   0.14892D-03
Top Left RCS Thrusters Assembl      26     0.12315D-01  -0.57541D-01   0.24273D-01  -0.39542D-03  -0.55672D-05   0.15062D-03
Top Left RCS Thrusters Assembl      26     0.12315D-01  -0.57541D-01   0.24273D-01  -0.39542D-03  -0.55672D-05   0.15062D-03
Bottom Right RCS Thruster Asse      27    -0.14784D-01   0.52926D-01  -0.24634D-01  -0.39571D-03  -0.16060D-04   0.18100D-03
Bottom Right RCS Thruster Asse      27    -0.14784D-01   0.52926D-01  -0.24634D-01  -0.39571D-03  -0.16060D-04   0.18100D-03
Bottom Left RCS Thrusters Asse      28     0.10988D-01   0.52953D-01   0.24271D-01  -0.39391D-03  -0.14677D-04   0.18006D-03
Bottom Left RCS Thrusters Asse      28     0.10988D-01   0.52953D-01   0.24271D-01  -0.39391D-03  -0.14677D-04   0.18006D-03
Center Habitat Module               21    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03
Center Habitat Module               21    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03
Center Habitat Module               21    -0.49088D-02   0.94551D-03  -0.70110D-02  -0.45210D-03  -0.82361D-04   0.32564D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.11933D-01  -0.22978D-02  -0.24480D-01  -0.27578D-03  -0.18136D-04   0.90617D-04
Right Keel/Boom Intrsect, CMG       10    -0.11933D-01  -0.22978D-02  -0.24480D-01  -0.27578D-03  -0.18136D-04   0.90617D-04
Right Keel/Boom Intrsect, CMG       10    -0.11933D-01  -0.22978D-02  -0.24480D-01  -0.27578D-03  -0.18136D-04   0.90617D-04
Payload boom, (top-right)            1    -0.85935D-02  -0.64021D-01  -0.24633D-01  -0.38690D-03  -0.21438D-04   0.15562D-03
Payload boom, (top-right)            1    -0.85935D-02  -0.64021D-01  -0.24633D-01  -0.38690D-03  -0.21438D-04   0.15562D-03
Payload boom, (top-right)            1    -0.85935D-02  -0.64021D-01  -0.24633D-01  -0.38690D-03  -0.21438D-04   0.15562D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)         9    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)         9    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Solar Array Boom               5     0.26037D-01  -0.24062D-02   0.63273D-01   0.89629D-03   0.24653D-03  -0.36480D-03
Right Solar Array Boom               5     0.26037D-01  -0.24062D-02   0.63273D-01   0.89629D-03   0.24653D-03  -0.36480D-03
Left SA Boom, Extreeme End          18    -0.28041D-01  -0.21711D-02  -0.65793D-01   0.91490D-03   0.86270D-04  -0.38602D-03
Left SA Boom, Extreeme End          18    -0.28041D-01  -0.21711D-02  -0.65793D-01   0.91490D-03   0.86270D-04  -0.38602D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)         9    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Right Boom (Sensor Assembly)         9    -0.12976D-01  -0.23098D-02  -0.27933D-01  -0.15851D-03  -0.83663D-05   0.43073D-04
Bottom Payload Boom (Left) Ant      24     0.10725D-01   0.59416D-01   0.24281D-01  -0.38656D-03  -0.15090D-04   0.19001D-03
Bottom Payload Boom (Left) Ant      24     0.10725D-01   0.59416D-01   0.24281D-01  -0.38656D-03  -0.15090D-04   0.19001D-03
Bottom Payload Boom (Left) Ant      24     0.10725D-01   0.59416D-01   0.24281D-01  -0.38656D-03  -0.15090D-04   0.19001D-03
Right SA Boom, Outboard the Hi       7    -0.95643D-02  -0.23488D-02  -0.22348D-01   0.58526D-03   0.71408D-04  -0.24985D-03
Left SA Boom, Outboard the Hin      16     0.93410D-02  -0.22219D-02   0.21678D-01   0.59934D-03   0.63853D-04  -0.26172D-03

MODE# 18/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.0756       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.52895D-01   0.74185D-02   0.75969D-03   0.38694D-04  -0.20796D-03  -0.70841D-03
Top Right RCS Thruster Assembl      25     0.52895D-01   0.74185D-02   0.75969D-03   0.38694D-04  -0.20796D-03  -0.70841D-03
Top Left RCS Thrusters Assembl      26    -0.48172D-01   0.74428D-02  -0.24789D-02   0.37535D-04   0.20417D-03  -0.67957D-03
Top Left RCS Thrusters Assembl      26    -0.48172D-01   0.74428D-02  -0.24789D-02   0.37535D-04   0.20417D-03  -0.67957D-03
Bottom Right RCS Thruster Asse      27    -0.46593D-01  -0.56516D-02   0.75386D-03   0.36593D-04  -0.20848D-03   0.66162D-03
Bottom Right RCS Thruster Asse      27    -0.46593D-01  -0.56516D-02   0.75386D-03   0.36593D-04  -0.20848D-03   0.66162D-03
Bottom Left RCS Thrusters Asse      28     0.51815D-01  -0.56769D-02  -0.24712D-02   0.35280D-04   0.21773D-03   0.69059D-03
Bottom Left RCS Thrusters Asse      28     0.51815D-01  -0.56769D-02  -0.24712D-02   0.35280D-04   0.21773D-03   0.69059D-03
Center Habitat Module               21    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05
Center Habitat Module               21    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05
Center Habitat Module               21    -0.19072D-02   0.14924D-03   0.32221D-03   0.60776D-04   0.53758D-04   0.57024D-05

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.32345D-02   0.65956D-03   0.71006D-03   0.32050D-04  -0.47929D-03  -0.11410D-03
Right Keel/Boom Intrsect, CMG       10     0.32345D-02   0.65956D-03   0.71006D-03   0.32050D-04  -0.47929D-03  -0.11410D-03
Right Keel/Boom Intrsect, CMG       10     0.32345D-02   0.65956D-03   0.71006D-03   0.32050D-04  -0.47929D-03  -0.11410D-03
Payload boom, (top-right)            1     0.56017D-01   0.80304D-02   0.76496D-03   0.33882D-04  -0.18829D-03  -0.77740D-03
Payload boom, (top-right)            1     0.56017D-01   0.80304D-02   0.76496D-03   0.33882D-04  -0.18829D-03  -0.77740D-03
Payload boom, (top-right)            1     0.56017D-01   0.80304D-02   0.76496D-03   0.33882D-04  -0.18829D-03  -0.77740D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)         9     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)         9     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Solar Array Boom               5     0.27361D-01   0.67385D-03   0.13286D-01   0.93424D-04  -0.27704D-02  -0.11120D-03
Right Solar Array Boom               5     0.27361D-01   0.67385D-03   0.13286D-01   0.93424D-04  -0.27704D-02  -0.11120D-03
Left SA Boom, Extreeme End          18     0.28521D-01   0.68685D-03  -0.11599D-01   0.59314D-04   0.26875D-02   0.15059D-03
Left SA Boom, Extreeme End          18     0.28521D-01   0.68685D-03  -0.11599D-01   0.59314D-04   0.26875D-02   0.15059D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)         9     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Right Boom (Sensor Assembly)         9     0.54691D-02   0.66378D-03   0.10582D-02   0.31814D-04  -0.78967D-03  -0.13552D-03
Bottom Payload Boom (Left) Ant      24     0.55098D-01  -0.62342D-02  -0.24763D-02   0.31274D-04   0.19756D-03   0.75902D-03
Bottom Payload Boom (Left) Ant      24     0.55098D-01  -0.62342D-02  -0.24763D-02   0.31274D-04   0.19756D-03   0.75902D-03
Bottom Payload Boom (Left) Ant      24     0.55098D-01  -0.62342D-02  -0.24763D-02   0.31274D-04   0.19756D-03   0.75902D-03
Right SA Boom, Outboard the Hi       7     0.14550D-01   0.67197D-03   0.37808D-02   0.80761D-04  -0.16634D-02  -0.14162D-03
Left SA Boom, Outboard the Hin      16     0.12023D-01   0.67953D-03  -0.53349D-02   0.58961D-04   0.16200D-02   0.16415D-03

MODE# 19/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.4152       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.94391D-02   0.11200D-01  -0.12533D-02   0.41230D-04  -0.33653D-04  -0.10106D-03
Top Right RCS Thruster Assembl      25     0.94391D-02   0.11200D-01  -0.12533D-02   0.41230D-04  -0.33653D-04  -0.10106D-03
Top Left RCS Thrusters Assembl      26    -0.11844D-02   0.11329D-01  -0.28415D-02   0.34799D-04  -0.68663D-05  -0.83633D-04
Top Left RCS Thrusters Assembl      26    -0.11844D-02   0.11329D-01  -0.28415D-02   0.34799D-04  -0.68663D-05  -0.83633D-04
Bottom Right RCS Thruster Asse      27     0.78951D-01  -0.20763D-03  -0.13276D-02   0.18558D-04   0.66571D-03  -0.20304D-03
Bottom Right RCS Thruster Asse      27     0.78951D-01  -0.20763D-03  -0.13276D-02   0.18558D-04   0.66571D-03  -0.20304D-03
Bottom Left RCS Thrusters Asse      28     0.51808D-01  -0.30836D-03  -0.27675D-02   0.13678D-04   0.55160D-03  -0.23243D-03
Bottom Left RCS Thrusters Asse      28     0.51808D-01  -0.30836D-03  -0.27675D-02   0.13678D-04   0.55160D-03  -0.23243D-03
Center Habitat Module               21    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03
Center Habitat Module               21    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03
Center Habitat Module               21    -0.60097D-02   0.28746D-02  -0.44442D-02  -0.16632D-03  -0.52907D-04   0.20466D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10     0.73885D-02   0.32383D-02  -0.13324D-02   0.23858D-04   0.39733D-04  -0.19098D-03
Right Keel/Boom Intrsect, CMG       10     0.73885D-02   0.32383D-02  -0.13324D-02   0.23858D-04   0.39733D-04  -0.19098D-03
Right Keel/Boom Intrsect, CMG       10     0.73885D-02   0.32383D-02  -0.13324D-02   0.23858D-04   0.39733D-04  -0.19098D-03
Payload boom, (top-right)            1     0.10013D-01   0.11834D-01  -0.12437D-02   0.31679D-04  -0.33017D-04  -0.91780D-04
Payload boom, (top-right)            1     0.10013D-01   0.11834D-01  -0.12437D-02   0.31679D-04  -0.33017D-04  -0.91780D-04
Payload boom, (top-right)            1     0.10013D-01   0.11834D-01  -0.12437D-02   0.31679D-04  -0.33017D-04  -0.91780D-04

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)         9     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)         9     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Solar Array Boom               5     0.14533D-01   0.33289D-02   0.11680D-01   0.10088D-03  -0.23347D-02   0.89641D-04
Right Solar Array Boom               5     0.14533D-01   0.33289D-02   0.11680D-01   0.10088D-03  -0.23347D-02   0.89641D-04
Left SA Boom, Extreeme End          18    -0.22738D-01   0.34691D-02   0.15481D-01  -0.18997D-03  -0.22979D-02  -0.92904D-04
Left SA Boom, Extreeme End          18    -0.22738D-01   0.34691D-02   0.15481D-01  -0.18997D-03  -0.22979D-02  -0.92904D-04

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)         9     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Right Boom (Sensor Assembly)         9     0.10815D-01   0.32568D-02  -0.10491D-02   0.26546D-04  -0.25745D-03  -0.19537D-03
Bottom Payload Boom (Left) Ant      24     0.61105D-01  -0.51289D-03  -0.27706D-02   0.11964D-04   0.55987D-03  -0.24272D-03
Bottom Payload Boom (Left) Ant      24     0.61105D-01  -0.51289D-03  -0.27706D-02   0.11964D-04   0.55987D-03  -0.24272D-03
Bottom Payload Boom (Left) Ant      24     0.61105D-01  -0.51289D-03  -0.27706D-02   0.11964D-04   0.55987D-03  -0.24272D-03
Right SA Boom, Outboard the Hi       7     0.20452D-01   0.33033D-02   0.15105D-02   0.83419D-04  -0.11449D-02  -0.27654D-04
Left SA Boom, Outboard the Hin      16    -0.11930D-01   0.34435D-02  -0.25508D-02  -0.12366D-03  -0.11806D-02  -0.12221D-03

MODE# 20/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.4305       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25     0.37109D-01   0.12551D-01  -0.20035D-02   0.77904D-04  -0.38630D-03   0.19223D-03
Top Right RCS Thruster Assembl      25     0.37109D-01   0.12551D-01  -0.20035D-02   0.77904D-04  -0.38630D-03   0.19223D-03
Top Left RCS Thrusters Assembl      26     0.61238D-01   0.12729D-01  -0.63322D-02   0.69130D-04  -0.48218D-03   0.18594D-03
Top Left RCS Thrusters Assembl      26     0.61238D-01   0.12729D-01  -0.63322D-02   0.69130D-04  -0.48218D-03   0.18594D-03
Bottom Right RCS Thruster Asse      27     0.19108D-01  -0.25557D-01  -0.19012D-02   0.10699D-03   0.18133D-03   0.45269D-04
Bottom Right RCS Thruster Asse      27     0.19108D-01  -0.25557D-01  -0.19012D-02   0.10699D-03   0.18133D-03   0.45269D-04
Bottom Left RCS Thrusters Asse      28     0.24644D-01  -0.25726D-01  -0.64322D-02   0.98580D-04   0.18287D-03   0.53285D-04
Bottom Left RCS Thrusters Asse      28     0.24644D-01  -0.25726D-01  -0.64322D-02   0.98580D-04   0.18287D-03   0.53285D-04
Center Habitat Module               21    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03
Center Habitat Module               21    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03
Center Habitat Module               21    -0.19542D-02  -0.14628D-02  -0.87479D-02  -0.32126D-03  -0.99014D-04  -0.10833D-03

                              Node Numb    Modal Data at the  6 Torque Application Points
Right Keel/Boom Intrsect, CMG       10    -0.29848D-03  -0.35494D-02  -0.21238D-02   0.92490D-04   0.18383D-04   0.41086D-04
Right Keel/Boom Intrsect, CMG       10    -0.29848D-03  -0.35494D-02  -0.21238D-02   0.92490D-04   0.18383D-04   0.41086D-04
Right Keel/Boom Intrsect, CMG       10    -0.29848D-03  -0.35494D-02  -0.21238D-02   0.92490D-04   0.18383D-04   0.41086D-04
Payload boom, (top-right)            1     0.43627D-01   0.13751D-01  -0.19888D-02   0.63014D-04  -0.39280D-03   0.20470D-03
Payload boom, (top-right)            1     0.43627D-01   0.13751D-01  -0.19888D-02   0.63014D-04  -0.39280D-03   0.20470D-03
Payload boom, (top-right)            1     0.43627D-01   0.13751D-01  -0.19888D-02   0.63014D-04  -0.39280D-03   0.20470D-03

                              Node Numb    Modal Data at the  7 Linear Translation Measurement Points
Right Boom (Sensor Assembly)         9    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)         9    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)         9    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Solar Array Boom               5    -0.13564D-01  -0.36593D-02  -0.10645D-01  -0.12371D-03   0.12817D-02   0.74429D-04
Right Solar Array Boom               5    -0.13564D-01  -0.36593D-02  -0.10645D-01  -0.12371D-03   0.12817D-02   0.74429D-04
Left SA Boom, Extreeme End          18     0.55886D-02  -0.36294D-02   0.11115D-03  -0.14774D-03   0.15899D-02  -0.15343D-03
Left SA Boom, Extreeme End          18     0.55886D-02  -0.36294D-02   0.11115D-03  -0.14774D-03   0.15899D-02  -0.15343D-03

                              Node Numb    Modal Data at the  8 Rotation Measurement Points
Right Boom (Sensor Assembly)         9    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)         9    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Right Boom (Sensor Assembly)         9    -0.11853D-02  -0.35688D-02  -0.70241D-03   0.74232D-04   0.18302D-03   0.55794D-04
Bottom Payload Boom (Left) Ant      24     0.27731D-01  -0.27204D-01  -0.64614D-02   0.74501D-04   0.18424D-03   0.42593D-04
Bottom Payload Boom (Left) Ant      24     0.27731D-01  -0.27204D-01  -0.64614D-02   0.74501D-04   0.18424D-03   0.42593D-04
Bottom Payload Boom (Left) Ant      24     0.27731D-01  -0.27204D-01  -0.64614D-02   0.74501D-04   0.18424D-03   0.42593D-04
Right SA Boom, Outboard the Hi       7    -0.54886D-02  -0.36226D-02   0.82965D-03  -0.68192D-04   0.66226D-03   0.80407D-04
Left SA Boom, Outboard the Hin      16     0.18229D-01  -0.35673D-02  -0.12053D-01  -0.47971D-04   0.73162D-03  -0.31724D-04

MODE# 21/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.5128       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node Numb    Modal Data at the 11 Force Application Points
Top Right RCS Thruster Assembl      25    -0.79555D-01   0.12043D-01   0.57402D-02   0.48800D-04   0.79964D-03  -0.24364D-03
Top Right RCS Thruster Assembl      25    -0.79555D-01   0.12043D-01   0.57402D-02   0.48800D-04   0.79964D-03  -0.24364D-03
Top Left RCS Thrusters Assembl      26    -0.11077D+00   0.11824D-01   0.29289D-02   0.59885D-04   0.93769D-03  -0.23210D-03
Top Left RCS Thrusters Assembl      26    -0.11077D+00   0.11824D-01   0.29289D-02   0.59885D-04   0.93769D-03  -0.23210D-03
Bottom Right RCS Thruster Asse      27    -0.97108D-01  -0.12162D-01   0.57573D-02   0.53230D-04  -0.89336D-03   0.90630D-04
Bottom Right RCS Thruster Asse      27    -0.97108D-01  -0.12162D-01   0.57573D-02   0.53230D-04  -0.89336D-03   0.90630D-04
Bottom Left RCS Thrusters Asse      28    -0.83967D-01  -0.11987D-01   0.29239D-02   0.61667D-04  -0.79724D-03   0.10989D-03
